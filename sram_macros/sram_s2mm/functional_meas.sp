.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_0ck70 FIND v(dout1_0) AT=40.025n

.meas tran vdout1_1ck70 FIND v(dout1_1) AT=40.025n

.meas tran vdout1_2ck70 FIND v(dout1_2) AT=40.025n

.meas tran vdout1_3ck70 FIND v(dout1_3) AT=40.025n

.meas tran vdout1_4ck70 FIND v(dout1_4) AT=40.025n

.meas tran vdout1_5ck70 FIND v(dout1_5) AT=40.025n

.meas tran vdout1_6ck70 FIND v(dout1_6) AT=40.025n

.meas tran vdout1_7ck70 FIND v(dout1_7) AT=40.025n

.meas tran vdout1_0ck110 FIND v(dout1_0) AT=60.025n

.meas tran vdout1_1ck110 FIND v(dout1_1) AT=60.025n

.meas tran vdout1_2ck110 FIND v(dout1_2) AT=60.025n

.meas tran vdout1_3ck110 FIND v(dout1_3) AT=60.025n

.meas tran vdout1_4ck110 FIND v(dout1_4) AT=60.025n

.meas tran vdout1_5ck110 FIND v(dout1_5) AT=60.025n

.meas tran vdout1_6ck110 FIND v(dout1_6) AT=60.025n

.meas tran vdout1_7ck110 FIND v(dout1_7) AT=60.025n

.meas tran vdout1_0ck120 FIND v(dout1_0) AT=65.025n

.meas tran vdout1_1ck120 FIND v(dout1_1) AT=65.025n

.meas tran vdout1_2ck120 FIND v(dout1_2) AT=65.025n

.meas tran vdout1_3ck120 FIND v(dout1_3) AT=65.025n

.meas tran vdout1_4ck120 FIND v(dout1_4) AT=65.025n

.meas tran vdout1_5ck120 FIND v(dout1_5) AT=65.025n

.meas tran vdout1_6ck120 FIND v(dout1_6) AT=65.025n

.meas tran vdout1_7ck120 FIND v(dout1_7) AT=65.025n

.meas tran vdout1_0ck150 FIND v(dout1_0) AT=80.025n

.meas tran vdout1_1ck150 FIND v(dout1_1) AT=80.025n

.meas tran vdout1_2ck150 FIND v(dout1_2) AT=80.025n

.meas tran vdout1_3ck150 FIND v(dout1_3) AT=80.025n

.meas tran vdout1_4ck150 FIND v(dout1_4) AT=80.025n

.meas tran vdout1_5ck150 FIND v(dout1_5) AT=80.025n

.meas tran vdout1_6ck150 FIND v(dout1_6) AT=80.025n

.meas tran vdout1_7ck150 FIND v(dout1_7) AT=80.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_0ck210 FIND v(dout1_0) AT=110.025n

.meas tran vdout1_1ck210 FIND v(dout1_1) AT=110.025n

.meas tran vdout1_2ck210 FIND v(dout1_2) AT=110.025n

.meas tran vdout1_3ck210 FIND v(dout1_3) AT=110.025n

.meas tran vdout1_4ck210 FIND v(dout1_4) AT=110.025n

.meas tran vdout1_5ck210 FIND v(dout1_5) AT=110.025n

.meas tran vdout1_6ck210 FIND v(dout1_6) AT=110.025n

.meas tran vdout1_7ck210 FIND v(dout1_7) AT=110.025n

.meas tran vdout1_0ck220 FIND v(dout1_0) AT=115.025n

.meas tran vdout1_1ck220 FIND v(dout1_1) AT=115.025n

.meas tran vdout1_2ck220 FIND v(dout1_2) AT=115.025n

.meas tran vdout1_3ck220 FIND v(dout1_3) AT=115.025n

.meas tran vdout1_4ck220 FIND v(dout1_4) AT=115.025n

.meas tran vdout1_5ck220 FIND v(dout1_5) AT=115.025n

.meas tran vdout1_6ck220 FIND v(dout1_6) AT=115.025n

.meas tran vdout1_7ck220 FIND v(dout1_7) AT=115.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_0ck270 FIND v(dout1_0) AT=140.025n

.meas tran vdout1_1ck270 FIND v(dout1_1) AT=140.025n

.meas tran vdout1_2ck270 FIND v(dout1_2) AT=140.025n

.meas tran vdout1_3ck270 FIND v(dout1_3) AT=140.025n

.meas tran vdout1_4ck270 FIND v(dout1_4) AT=140.025n

.meas tran vdout1_5ck270 FIND v(dout1_5) AT=140.025n

.meas tran vdout1_6ck270 FIND v(dout1_6) AT=140.025n

.meas tran vdout1_7ck270 FIND v(dout1_7) AT=140.025n

.meas tran vdout1_0ck300 FIND v(dout1_0) AT=155.025n

.meas tran vdout1_1ck300 FIND v(dout1_1) AT=155.025n

.meas tran vdout1_2ck300 FIND v(dout1_2) AT=155.025n

.meas tran vdout1_3ck300 FIND v(dout1_3) AT=155.025n

.meas tran vdout1_4ck300 FIND v(dout1_4) AT=155.025n

.meas tran vdout1_5ck300 FIND v(dout1_5) AT=155.025n

.meas tran vdout1_6ck300 FIND v(dout1_6) AT=155.025n

.meas tran vdout1_7ck300 FIND v(dout1_7) AT=155.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_0ck340 FIND v(dout1_0) AT=175.025n

.meas tran vdout1_1ck340 FIND v(dout1_1) AT=175.025n

.meas tran vdout1_2ck340 FIND v(dout1_2) AT=175.025n

.meas tran vdout1_3ck340 FIND v(dout1_3) AT=175.025n

.meas tran vdout1_4ck340 FIND v(dout1_4) AT=175.025n

.meas tran vdout1_5ck340 FIND v(dout1_5) AT=175.025n

.meas tran vdout1_6ck340 FIND v(dout1_6) AT=175.025n

.meas tran vdout1_7ck340 FIND v(dout1_7) AT=175.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_0ck380 FIND v(dout1_0) AT=195.025n

.meas tran vdout1_1ck380 FIND v(dout1_1) AT=195.025n

.meas tran vdout1_2ck380 FIND v(dout1_2) AT=195.025n

.meas tran vdout1_3ck380 FIND v(dout1_3) AT=195.025n

.meas tran vdout1_4ck380 FIND v(dout1_4) AT=195.025n

.meas tran vdout1_5ck380 FIND v(dout1_5) AT=195.025n

.meas tran vdout1_6ck380 FIND v(dout1_6) AT=195.025n

.meas tran vdout1_7ck380 FIND v(dout1_7) AT=195.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_0ck400 FIND v(dout1_0) AT=205.025n

.meas tran vdout1_1ck400 FIND v(dout1_1) AT=205.025n

.meas tran vdout1_2ck400 FIND v(dout1_2) AT=205.025n

.meas tran vdout1_3ck400 FIND v(dout1_3) AT=205.025n

.meas tran vdout1_4ck400 FIND v(dout1_4) AT=205.025n

.meas tran vdout1_5ck400 FIND v(dout1_5) AT=205.025n

.meas tran vdout1_6ck400 FIND v(dout1_6) AT=205.025n

.meas tran vdout1_7ck400 FIND v(dout1_7) AT=205.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_0ck470 FIND v(dout1_0) AT=240.025n

.meas tran vdout1_1ck470 FIND v(dout1_1) AT=240.025n

.meas tran vdout1_2ck470 FIND v(dout1_2) AT=240.025n

.meas tran vdout1_3ck470 FIND v(dout1_3) AT=240.025n

.meas tran vdout1_4ck470 FIND v(dout1_4) AT=240.025n

.meas tran vdout1_5ck470 FIND v(dout1_5) AT=240.025n

.meas tran vdout1_6ck470 FIND v(dout1_6) AT=240.025n

.meas tran vdout1_7ck470 FIND v(dout1_7) AT=240.025n

.meas tran vdout1_0ck500 FIND v(dout1_0) AT=255.025n

.meas tran vdout1_1ck500 FIND v(dout1_1) AT=255.025n

.meas tran vdout1_2ck500 FIND v(dout1_2) AT=255.025n

.meas tran vdout1_3ck500 FIND v(dout1_3) AT=255.025n

.meas tran vdout1_4ck500 FIND v(dout1_4) AT=255.025n

.meas tran vdout1_5ck500 FIND v(dout1_5) AT=255.025n

.meas tran vdout1_6ck500 FIND v(dout1_6) AT=255.025n

.meas tran vdout1_7ck500 FIND v(dout1_7) AT=255.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_0ck580 FIND v(dout1_0) AT=295.025n

.meas tran vdout1_1ck580 FIND v(dout1_1) AT=295.025n

.meas tran vdout1_2ck580 FIND v(dout1_2) AT=295.025n

.meas tran vdout1_3ck580 FIND v(dout1_3) AT=295.025n

.meas tran vdout1_4ck580 FIND v(dout1_4) AT=295.025n

.meas tran vdout1_5ck580 FIND v(dout1_5) AT=295.025n

.meas tran vdout1_6ck580 FIND v(dout1_6) AT=295.025n

.meas tran vdout1_7ck580 FIND v(dout1_7) AT=295.025n

.meas tran vdout1_0ck620 FIND v(dout1_0) AT=315.025n

.meas tran vdout1_1ck620 FIND v(dout1_1) AT=315.025n

.meas tran vdout1_2ck620 FIND v(dout1_2) AT=315.025n

.meas tran vdout1_3ck620 FIND v(dout1_3) AT=315.025n

.meas tran vdout1_4ck620 FIND v(dout1_4) AT=315.025n

.meas tran vdout1_5ck620 FIND v(dout1_5) AT=315.025n

.meas tran vdout1_6ck620 FIND v(dout1_6) AT=315.025n

.meas tran vdout1_7ck620 FIND v(dout1_7) AT=315.025n

.meas tran vdout1_0ck630 FIND v(dout1_0) AT=320.025n

.meas tran vdout1_1ck630 FIND v(dout1_1) AT=320.025n

.meas tran vdout1_2ck630 FIND v(dout1_2) AT=320.025n

.meas tran vdout1_3ck630 FIND v(dout1_3) AT=320.025n

.meas tran vdout1_4ck630 FIND v(dout1_4) AT=320.025n

.meas tran vdout1_5ck630 FIND v(dout1_5) AT=320.025n

.meas tran vdout1_6ck630 FIND v(dout1_6) AT=320.025n

.meas tran vdout1_7ck630 FIND v(dout1_7) AT=320.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_0ck700 FIND v(dout1_0) AT=355.025n

.meas tran vdout1_1ck700 FIND v(dout1_1) AT=355.025n

.meas tran vdout1_2ck700 FIND v(dout1_2) AT=355.025n

.meas tran vdout1_3ck700 FIND v(dout1_3) AT=355.025n

.meas tran vdout1_4ck700 FIND v(dout1_4) AT=355.025n

.meas tran vdout1_5ck700 FIND v(dout1_5) AT=355.025n

.meas tran vdout1_6ck700 FIND v(dout1_6) AT=355.025n

.meas tran vdout1_7ck700 FIND v(dout1_7) AT=355.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_0ck780 FIND v(dout1_0) AT=395.025n

.meas tran vdout1_1ck780 FIND v(dout1_1) AT=395.025n

.meas tran vdout1_2ck780 FIND v(dout1_2) AT=395.025n

.meas tran vdout1_3ck780 FIND v(dout1_3) AT=395.025n

.meas tran vdout1_4ck780 FIND v(dout1_4) AT=395.025n

.meas tran vdout1_5ck780 FIND v(dout1_5) AT=395.025n

.meas tran vdout1_6ck780 FIND v(dout1_6) AT=395.025n

.meas tran vdout1_7ck780 FIND v(dout1_7) AT=395.025n

.meas tran vdout1_0ck800 FIND v(dout1_0) AT=405.025n

.meas tran vdout1_1ck800 FIND v(dout1_1) AT=405.025n

.meas tran vdout1_2ck800 FIND v(dout1_2) AT=405.025n

.meas tran vdout1_3ck800 FIND v(dout1_3) AT=405.025n

.meas tran vdout1_4ck800 FIND v(dout1_4) AT=405.025n

.meas tran vdout1_5ck800 FIND v(dout1_5) AT=405.025n

.meas tran vdout1_6ck800 FIND v(dout1_6) AT=405.025n

.meas tran vdout1_7ck800 FIND v(dout1_7) AT=405.025n

.meas tran vdout1_0ck810 FIND v(dout1_0) AT=410.025n

.meas tran vdout1_1ck810 FIND v(dout1_1) AT=410.025n

.meas tran vdout1_2ck810 FIND v(dout1_2) AT=410.025n

.meas tran vdout1_3ck810 FIND v(dout1_3) AT=410.025n

.meas tran vdout1_4ck810 FIND v(dout1_4) AT=410.025n

.meas tran vdout1_5ck810 FIND v(dout1_5) AT=410.025n

.meas tran vdout1_6ck810 FIND v(dout1_6) AT=410.025n

.meas tran vdout1_7ck810 FIND v(dout1_7) AT=410.025n

.meas tran vdout1_0ck830 FIND v(dout1_0) AT=420.025n

.meas tran vdout1_1ck830 FIND v(dout1_1) AT=420.025n

.meas tran vdout1_2ck830 FIND v(dout1_2) AT=420.025n

.meas tran vdout1_3ck830 FIND v(dout1_3) AT=420.025n

.meas tran vdout1_4ck830 FIND v(dout1_4) AT=420.025n

.meas tran vdout1_5ck830 FIND v(dout1_5) AT=420.025n

.meas tran vdout1_6ck830 FIND v(dout1_6) AT=420.025n

.meas tran vdout1_7ck830 FIND v(dout1_7) AT=420.025n

.meas tran vdout1_0ck850 FIND v(dout1_0) AT=430.025n

.meas tran vdout1_1ck850 FIND v(dout1_1) AT=430.025n

.meas tran vdout1_2ck850 FIND v(dout1_2) AT=430.025n

.meas tran vdout1_3ck850 FIND v(dout1_3) AT=430.025n

.meas tran vdout1_4ck850 FIND v(dout1_4) AT=430.025n

.meas tran vdout1_5ck850 FIND v(dout1_5) AT=430.025n

.meas tran vdout1_6ck850 FIND v(dout1_6) AT=430.025n

.meas tran vdout1_7ck850 FIND v(dout1_7) AT=430.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_0ck870 FIND v(dout1_0) AT=440.025n

.meas tran vdout1_1ck870 FIND v(dout1_1) AT=440.025n

.meas tran vdout1_2ck870 FIND v(dout1_2) AT=440.025n

.meas tran vdout1_3ck870 FIND v(dout1_3) AT=440.025n

.meas tran vdout1_4ck870 FIND v(dout1_4) AT=440.025n

.meas tran vdout1_5ck870 FIND v(dout1_5) AT=440.025n

.meas tran vdout1_6ck870 FIND v(dout1_6) AT=440.025n

.meas tran vdout1_7ck870 FIND v(dout1_7) AT=440.025n

.meas tran vdout1_0ck990 FIND v(dout1_0) AT=500.025n

.meas tran vdout1_1ck990 FIND v(dout1_1) AT=500.025n

.meas tran vdout1_2ck990 FIND v(dout1_2) AT=500.025n

.meas tran vdout1_3ck990 FIND v(dout1_3) AT=500.025n

.meas tran vdout1_4ck990 FIND v(dout1_4) AT=500.025n

.meas tran vdout1_5ck990 FIND v(dout1_5) AT=500.025n

.meas tran vdout1_6ck990 FIND v(dout1_6) AT=500.025n

.meas tran vdout1_7ck990 FIND v(dout1_7) AT=500.025n

.meas tran vdout1_0ck1000 FIND v(dout1_0) AT=505.025n

.meas tran vdout1_1ck1000 FIND v(dout1_1) AT=505.025n

.meas tran vdout1_2ck1000 FIND v(dout1_2) AT=505.025n

.meas tran vdout1_3ck1000 FIND v(dout1_3) AT=505.025n

.meas tran vdout1_4ck1000 FIND v(dout1_4) AT=505.025n

.meas tran vdout1_5ck1000 FIND v(dout1_5) AT=505.025n

.meas tran vdout1_6ck1000 FIND v(dout1_6) AT=505.025n

.meas tran vdout1_7ck1000 FIND v(dout1_7) AT=505.025n

.meas tran vdout1_0ck1010 FIND v(dout1_0) AT=510.025n

.meas tran vdout1_1ck1010 FIND v(dout1_1) AT=510.025n

.meas tran vdout1_2ck1010 FIND v(dout1_2) AT=510.025n

.meas tran vdout1_3ck1010 FIND v(dout1_3) AT=510.025n

.meas tran vdout1_4ck1010 FIND v(dout1_4) AT=510.025n

.meas tran vdout1_5ck1010 FIND v(dout1_5) AT=510.025n

.meas tran vdout1_6ck1010 FIND v(dout1_6) AT=510.025n

.meas tran vdout1_7ck1010 FIND v(dout1_7) AT=510.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_0ck1040 FIND v(dout1_0) AT=525.025n

.meas tran vdout1_1ck1040 FIND v(dout1_1) AT=525.025n

.meas tran vdout1_2ck1040 FIND v(dout1_2) AT=525.025n

.meas tran vdout1_3ck1040 FIND v(dout1_3) AT=525.025n

.meas tran vdout1_4ck1040 FIND v(dout1_4) AT=525.025n

.meas tran vdout1_5ck1040 FIND v(dout1_5) AT=525.025n

.meas tran vdout1_6ck1040 FIND v(dout1_6) AT=525.025n

.meas tran vdout1_7ck1040 FIND v(dout1_7) AT=525.025n

.meas tran vdout1_0ck1070 FIND v(dout1_0) AT=540.025n

.meas tran vdout1_1ck1070 FIND v(dout1_1) AT=540.025n

.meas tran vdout1_2ck1070 FIND v(dout1_2) AT=540.025n

.meas tran vdout1_3ck1070 FIND v(dout1_3) AT=540.025n

.meas tran vdout1_4ck1070 FIND v(dout1_4) AT=540.025n

.meas tran vdout1_5ck1070 FIND v(dout1_5) AT=540.025n

.meas tran vdout1_6ck1070 FIND v(dout1_6) AT=540.025n

.meas tran vdout1_7ck1070 FIND v(dout1_7) AT=540.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_0ck1160 FIND v(dout1_0) AT=585.025n

.meas tran vdout1_1ck1160 FIND v(dout1_1) AT=585.025n

.meas tran vdout1_2ck1160 FIND v(dout1_2) AT=585.025n

.meas tran vdout1_3ck1160 FIND v(dout1_3) AT=585.025n

.meas tran vdout1_4ck1160 FIND v(dout1_4) AT=585.025n

.meas tran vdout1_5ck1160 FIND v(dout1_5) AT=585.025n

.meas tran vdout1_6ck1160 FIND v(dout1_6) AT=585.025n

.meas tran vdout1_7ck1160 FIND v(dout1_7) AT=585.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_0ck1230 FIND v(dout1_0) AT=620.025n

.meas tran vdout1_1ck1230 FIND v(dout1_1) AT=620.025n

.meas tran vdout1_2ck1230 FIND v(dout1_2) AT=620.025n

.meas tran vdout1_3ck1230 FIND v(dout1_3) AT=620.025n

.meas tran vdout1_4ck1230 FIND v(dout1_4) AT=620.025n

.meas tran vdout1_5ck1230 FIND v(dout1_5) AT=620.025n

.meas tran vdout1_6ck1230 FIND v(dout1_6) AT=620.025n

.meas tran vdout1_7ck1230 FIND v(dout1_7) AT=620.025n

.meas tran vdout1_0ck1270 FIND v(dout1_0) AT=640.025n

.meas tran vdout1_1ck1270 FIND v(dout1_1) AT=640.025n

.meas tran vdout1_2ck1270 FIND v(dout1_2) AT=640.025n

.meas tran vdout1_3ck1270 FIND v(dout1_3) AT=640.025n

.meas tran vdout1_4ck1270 FIND v(dout1_4) AT=640.025n

.meas tran vdout1_5ck1270 FIND v(dout1_5) AT=640.025n

.meas tran vdout1_6ck1270 FIND v(dout1_6) AT=640.025n

.meas tran vdout1_7ck1270 FIND v(dout1_7) AT=640.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_0ck1300 FIND v(dout1_0) AT=655.025n

.meas tran vdout1_1ck1300 FIND v(dout1_1) AT=655.025n

.meas tran vdout1_2ck1300 FIND v(dout1_2) AT=655.025n

.meas tran vdout1_3ck1300 FIND v(dout1_3) AT=655.025n

.meas tran vdout1_4ck1300 FIND v(dout1_4) AT=655.025n

.meas tran vdout1_5ck1300 FIND v(dout1_5) AT=655.025n

.meas tran vdout1_6ck1300 FIND v(dout1_6) AT=655.025n

.meas tran vdout1_7ck1300 FIND v(dout1_7) AT=655.025n

.meas tran vdout1_0ck1320 FIND v(dout1_0) AT=665.025n

.meas tran vdout1_1ck1320 FIND v(dout1_1) AT=665.025n

.meas tran vdout1_2ck1320 FIND v(dout1_2) AT=665.025n

.meas tran vdout1_3ck1320 FIND v(dout1_3) AT=665.025n

.meas tran vdout1_4ck1320 FIND v(dout1_4) AT=665.025n

.meas tran vdout1_5ck1320 FIND v(dout1_5) AT=665.025n

.meas tran vdout1_6ck1320 FIND v(dout1_6) AT=665.025n

.meas tran vdout1_7ck1320 FIND v(dout1_7) AT=665.025n

.meas tran vdout1_0ck1410 FIND v(dout1_0) AT=710.025n

.meas tran vdout1_1ck1410 FIND v(dout1_1) AT=710.025n

.meas tran vdout1_2ck1410 FIND v(dout1_2) AT=710.025n

.meas tran vdout1_3ck1410 FIND v(dout1_3) AT=710.025n

.meas tran vdout1_4ck1410 FIND v(dout1_4) AT=710.025n

.meas tran vdout1_5ck1410 FIND v(dout1_5) AT=710.025n

.meas tran vdout1_6ck1410 FIND v(dout1_6) AT=710.025n

.meas tran vdout1_7ck1410 FIND v(dout1_7) AT=710.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_0ck1430 FIND v(dout1_0) AT=720.025n

.meas tran vdout1_1ck1430 FIND v(dout1_1) AT=720.025n

.meas tran vdout1_2ck1430 FIND v(dout1_2) AT=720.025n

.meas tran vdout1_3ck1430 FIND v(dout1_3) AT=720.025n

.meas tran vdout1_4ck1430 FIND v(dout1_4) AT=720.025n

.meas tran vdout1_5ck1430 FIND v(dout1_5) AT=720.025n

.meas tran vdout1_6ck1430 FIND v(dout1_6) AT=720.025n

.meas tran vdout1_7ck1430 FIND v(dout1_7) AT=720.025n

.meas tran vdout1_0ck1440 FIND v(dout1_0) AT=725.025n

.meas tran vdout1_1ck1440 FIND v(dout1_1) AT=725.025n

.meas tran vdout1_2ck1440 FIND v(dout1_2) AT=725.025n

.meas tran vdout1_3ck1440 FIND v(dout1_3) AT=725.025n

.meas tran vdout1_4ck1440 FIND v(dout1_4) AT=725.025n

.meas tran vdout1_5ck1440 FIND v(dout1_5) AT=725.025n

.meas tran vdout1_6ck1440 FIND v(dout1_6) AT=725.025n

.meas tran vdout1_7ck1440 FIND v(dout1_7) AT=725.025n

.meas tran vdout1_0ck1450 FIND v(dout1_0) AT=730.025n

.meas tran vdout1_1ck1450 FIND v(dout1_1) AT=730.025n

.meas tran vdout1_2ck1450 FIND v(dout1_2) AT=730.025n

.meas tran vdout1_3ck1450 FIND v(dout1_3) AT=730.025n

.meas tran vdout1_4ck1450 FIND v(dout1_4) AT=730.025n

.meas tran vdout1_5ck1450 FIND v(dout1_5) AT=730.025n

.meas tran vdout1_6ck1450 FIND v(dout1_6) AT=730.025n

.meas tran vdout1_7ck1450 FIND v(dout1_7) AT=730.025n

.meas tran vdout1_0ck1470 FIND v(dout1_0) AT=740.025n

.meas tran vdout1_1ck1470 FIND v(dout1_1) AT=740.025n

.meas tran vdout1_2ck1470 FIND v(dout1_2) AT=740.025n

.meas tran vdout1_3ck1470 FIND v(dout1_3) AT=740.025n

.meas tran vdout1_4ck1470 FIND v(dout1_4) AT=740.025n

.meas tran vdout1_5ck1470 FIND v(dout1_5) AT=740.025n

.meas tran vdout1_6ck1470 FIND v(dout1_6) AT=740.025n

.meas tran vdout1_7ck1470 FIND v(dout1_7) AT=740.025n

.meas tran vdout1_0ck1510 FIND v(dout1_0) AT=760.025n

.meas tran vdout1_1ck1510 FIND v(dout1_1) AT=760.025n

.meas tran vdout1_2ck1510 FIND v(dout1_2) AT=760.025n

.meas tran vdout1_3ck1510 FIND v(dout1_3) AT=760.025n

.meas tran vdout1_4ck1510 FIND v(dout1_4) AT=760.025n

.meas tran vdout1_5ck1510 FIND v(dout1_5) AT=760.025n

.meas tran vdout1_6ck1510 FIND v(dout1_6) AT=760.025n

.meas tran vdout1_7ck1510 FIND v(dout1_7) AT=760.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_0ck1570 FIND v(dout1_0) AT=790.025n

.meas tran vdout1_1ck1570 FIND v(dout1_1) AT=790.025n

.meas tran vdout1_2ck1570 FIND v(dout1_2) AT=790.025n

.meas tran vdout1_3ck1570 FIND v(dout1_3) AT=790.025n

.meas tran vdout1_4ck1570 FIND v(dout1_4) AT=790.025n

.meas tran vdout1_5ck1570 FIND v(dout1_5) AT=790.025n

.meas tran vdout1_6ck1570 FIND v(dout1_6) AT=790.025n

.meas tran vdout1_7ck1570 FIND v(dout1_7) AT=790.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_0ck1710 FIND v(dout1_0) AT=860.025n

.meas tran vdout1_1ck1710 FIND v(dout1_1) AT=860.025n

.meas tran vdout1_2ck1710 FIND v(dout1_2) AT=860.025n

.meas tran vdout1_3ck1710 FIND v(dout1_3) AT=860.025n

.meas tran vdout1_4ck1710 FIND v(dout1_4) AT=860.025n

.meas tran vdout1_5ck1710 FIND v(dout1_5) AT=860.025n

.meas tran vdout1_6ck1710 FIND v(dout1_6) AT=860.025n

.meas tran vdout1_7ck1710 FIND v(dout1_7) AT=860.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_0ck1740 FIND v(dout1_0) AT=875.025n

.meas tran vdout1_1ck1740 FIND v(dout1_1) AT=875.025n

.meas tran vdout1_2ck1740 FIND v(dout1_2) AT=875.025n

.meas tran vdout1_3ck1740 FIND v(dout1_3) AT=875.025n

.meas tran vdout1_4ck1740 FIND v(dout1_4) AT=875.025n

.meas tran vdout1_5ck1740 FIND v(dout1_5) AT=875.025n

.meas tran vdout1_6ck1740 FIND v(dout1_6) AT=875.025n

.meas tran vdout1_7ck1740 FIND v(dout1_7) AT=875.025n

.meas tran vdout1_0ck1770 FIND v(dout1_0) AT=890.025n

.meas tran vdout1_1ck1770 FIND v(dout1_1) AT=890.025n

.meas tran vdout1_2ck1770 FIND v(dout1_2) AT=890.025n

.meas tran vdout1_3ck1770 FIND v(dout1_3) AT=890.025n

.meas tran vdout1_4ck1770 FIND v(dout1_4) AT=890.025n

.meas tran vdout1_5ck1770 FIND v(dout1_5) AT=890.025n

.meas tran vdout1_6ck1770 FIND v(dout1_6) AT=890.025n

.meas tran vdout1_7ck1770 FIND v(dout1_7) AT=890.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_0ck1850 FIND v(dout1_0) AT=930.025n

.meas tran vdout1_1ck1850 FIND v(dout1_1) AT=930.025n

.meas tran vdout1_2ck1850 FIND v(dout1_2) AT=930.025n

.meas tran vdout1_3ck1850 FIND v(dout1_3) AT=930.025n

.meas tran vdout1_4ck1850 FIND v(dout1_4) AT=930.025n

.meas tran vdout1_5ck1850 FIND v(dout1_5) AT=930.025n

.meas tran vdout1_6ck1850 FIND v(dout1_6) AT=930.025n

.meas tran vdout1_7ck1850 FIND v(dout1_7) AT=930.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_0ck1870 FIND v(dout1_0) AT=940.025n

.meas tran vdout1_1ck1870 FIND v(dout1_1) AT=940.025n

.meas tran vdout1_2ck1870 FIND v(dout1_2) AT=940.025n

.meas tran vdout1_3ck1870 FIND v(dout1_3) AT=940.025n

.meas tran vdout1_4ck1870 FIND v(dout1_4) AT=940.025n

.meas tran vdout1_5ck1870 FIND v(dout1_5) AT=940.025n

.meas tran vdout1_6ck1870 FIND v(dout1_6) AT=940.025n

.meas tran vdout1_7ck1870 FIND v(dout1_7) AT=940.025n

.meas tran vdout1_0ck1880 FIND v(dout1_0) AT=945.025n

.meas tran vdout1_1ck1880 FIND v(dout1_1) AT=945.025n

.meas tran vdout1_2ck1880 FIND v(dout1_2) AT=945.025n

.meas tran vdout1_3ck1880 FIND v(dout1_3) AT=945.025n

.meas tran vdout1_4ck1880 FIND v(dout1_4) AT=945.025n

.meas tran vdout1_5ck1880 FIND v(dout1_5) AT=945.025n

.meas tran vdout1_6ck1880 FIND v(dout1_6) AT=945.025n

.meas tran vdout1_7ck1880 FIND v(dout1_7) AT=945.025n

.meas tran vdout1_0ck1890 FIND v(dout1_0) AT=950.025n

.meas tran vdout1_1ck1890 FIND v(dout1_1) AT=950.025n

.meas tran vdout1_2ck1890 FIND v(dout1_2) AT=950.025n

.meas tran vdout1_3ck1890 FIND v(dout1_3) AT=950.025n

.meas tran vdout1_4ck1890 FIND v(dout1_4) AT=950.025n

.meas tran vdout1_5ck1890 FIND v(dout1_5) AT=950.025n

.meas tran vdout1_6ck1890 FIND v(dout1_6) AT=950.025n

.meas tran vdout1_7ck1890 FIND v(dout1_7) AT=950.025n

.meas tran vdout1_0ck1900 FIND v(dout1_0) AT=955.025n

.meas tran vdout1_1ck1900 FIND v(dout1_1) AT=955.025n

.meas tran vdout1_2ck1900 FIND v(dout1_2) AT=955.025n

.meas tran vdout1_3ck1900 FIND v(dout1_3) AT=955.025n

.meas tran vdout1_4ck1900 FIND v(dout1_4) AT=955.025n

.meas tran vdout1_5ck1900 FIND v(dout1_5) AT=955.025n

.meas tran vdout1_6ck1900 FIND v(dout1_6) AT=955.025n

.meas tran vdout1_7ck1900 FIND v(dout1_7) AT=955.025n

.meas tran vdout1_0ck1920 FIND v(dout1_0) AT=965.025n

.meas tran vdout1_1ck1920 FIND v(dout1_1) AT=965.025n

.meas tran vdout1_2ck1920 FIND v(dout1_2) AT=965.025n

.meas tran vdout1_3ck1920 FIND v(dout1_3) AT=965.025n

.meas tran vdout1_4ck1920 FIND v(dout1_4) AT=965.025n

.meas tran vdout1_5ck1920 FIND v(dout1_5) AT=965.025n

.meas tran vdout1_6ck1920 FIND v(dout1_6) AT=965.025n

.meas tran vdout1_7ck1920 FIND v(dout1_7) AT=965.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_0ck1990 FIND v(dout1_0) AT=1000.025n

.meas tran vdout1_1ck1990 FIND v(dout1_1) AT=1000.025n

.meas tran vdout1_2ck1990 FIND v(dout1_2) AT=1000.025n

.meas tran vdout1_3ck1990 FIND v(dout1_3) AT=1000.025n

.meas tran vdout1_4ck1990 FIND v(dout1_4) AT=1000.025n

.meas tran vdout1_5ck1990 FIND v(dout1_5) AT=1000.025n

.meas tran vdout1_6ck1990 FIND v(dout1_6) AT=1000.025n

.meas tran vdout1_7ck1990 FIND v(dout1_7) AT=1000.025n
