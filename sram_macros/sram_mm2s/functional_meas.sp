.meas tran vdout1_0ck40 FIND v(dout1_0) AT=25.025n

.meas tran vdout1_1ck40 FIND v(dout1_1) AT=25.025n

.meas tran vdout1_2ck40 FIND v(dout1_2) AT=25.025n

.meas tran vdout1_3ck40 FIND v(dout1_3) AT=25.025n

.meas tran vdout1_4ck40 FIND v(dout1_4) AT=25.025n

.meas tran vdout1_5ck40 FIND v(dout1_5) AT=25.025n

.meas tran vdout1_6ck40 FIND v(dout1_6) AT=25.025n

.meas tran vdout1_7ck40 FIND v(dout1_7) AT=25.025n

.meas tran vdout1_8ck40 FIND v(dout1_8) AT=25.025n

.meas tran vdout1_9ck40 FIND v(dout1_9) AT=25.025n

.meas tran vdout1_10ck40 FIND v(dout1_10) AT=25.025n

.meas tran vdout1_11ck40 FIND v(dout1_11) AT=25.025n

.meas tran vdout1_12ck40 FIND v(dout1_12) AT=25.025n

.meas tran vdout1_13ck40 FIND v(dout1_13) AT=25.025n

.meas tran vdout1_14ck40 FIND v(dout1_14) AT=25.025n

.meas tran vdout1_15ck40 FIND v(dout1_15) AT=25.025n

.meas tran vdout1_0ck60 FIND v(dout1_0) AT=35.025n

.meas tran vdout1_1ck60 FIND v(dout1_1) AT=35.025n

.meas tran vdout1_2ck60 FIND v(dout1_2) AT=35.025n

.meas tran vdout1_3ck60 FIND v(dout1_3) AT=35.025n

.meas tran vdout1_4ck60 FIND v(dout1_4) AT=35.025n

.meas tran vdout1_5ck60 FIND v(dout1_5) AT=35.025n

.meas tran vdout1_6ck60 FIND v(dout1_6) AT=35.025n

.meas tran vdout1_7ck60 FIND v(dout1_7) AT=35.025n

.meas tran vdout1_8ck60 FIND v(dout1_8) AT=35.025n

.meas tran vdout1_9ck60 FIND v(dout1_9) AT=35.025n

.meas tran vdout1_10ck60 FIND v(dout1_10) AT=35.025n

.meas tran vdout1_11ck60 FIND v(dout1_11) AT=35.025n

.meas tran vdout1_12ck60 FIND v(dout1_12) AT=35.025n

.meas tran vdout1_13ck60 FIND v(dout1_13) AT=35.025n

.meas tran vdout1_14ck60 FIND v(dout1_14) AT=35.025n

.meas tran vdout1_15ck60 FIND v(dout1_15) AT=35.025n

.meas tran vdout1_0ck70 FIND v(dout1_0) AT=40.025n

.meas tran vdout1_1ck70 FIND v(dout1_1) AT=40.025n

.meas tran vdout1_2ck70 FIND v(dout1_2) AT=40.025n

.meas tran vdout1_3ck70 FIND v(dout1_3) AT=40.025n

.meas tran vdout1_4ck70 FIND v(dout1_4) AT=40.025n

.meas tran vdout1_5ck70 FIND v(dout1_5) AT=40.025n

.meas tran vdout1_6ck70 FIND v(dout1_6) AT=40.025n

.meas tran vdout1_7ck70 FIND v(dout1_7) AT=40.025n

.meas tran vdout1_8ck70 FIND v(dout1_8) AT=40.025n

.meas tran vdout1_9ck70 FIND v(dout1_9) AT=40.025n

.meas tran vdout1_10ck70 FIND v(dout1_10) AT=40.025n

.meas tran vdout1_11ck70 FIND v(dout1_11) AT=40.025n

.meas tran vdout1_12ck70 FIND v(dout1_12) AT=40.025n

.meas tran vdout1_13ck70 FIND v(dout1_13) AT=40.025n

.meas tran vdout1_14ck70 FIND v(dout1_14) AT=40.025n

.meas tran vdout1_15ck70 FIND v(dout1_15) AT=40.025n

.meas tran vdout1_0ck80 FIND v(dout1_0) AT=45.025n

.meas tran vdout1_1ck80 FIND v(dout1_1) AT=45.025n

.meas tran vdout1_2ck80 FIND v(dout1_2) AT=45.025n

.meas tran vdout1_3ck80 FIND v(dout1_3) AT=45.025n

.meas tran vdout1_4ck80 FIND v(dout1_4) AT=45.025n

.meas tran vdout1_5ck80 FIND v(dout1_5) AT=45.025n

.meas tran vdout1_6ck80 FIND v(dout1_6) AT=45.025n

.meas tran vdout1_7ck80 FIND v(dout1_7) AT=45.025n

.meas tran vdout1_8ck80 FIND v(dout1_8) AT=45.025n

.meas tran vdout1_9ck80 FIND v(dout1_9) AT=45.025n

.meas tran vdout1_10ck80 FIND v(dout1_10) AT=45.025n

.meas tran vdout1_11ck80 FIND v(dout1_11) AT=45.025n

.meas tran vdout1_12ck80 FIND v(dout1_12) AT=45.025n

.meas tran vdout1_13ck80 FIND v(dout1_13) AT=45.025n

.meas tran vdout1_14ck80 FIND v(dout1_14) AT=45.025n

.meas tran vdout1_15ck80 FIND v(dout1_15) AT=45.025n

.meas tran vdout1_0ck160 FIND v(dout1_0) AT=85.025n

.meas tran vdout1_1ck160 FIND v(dout1_1) AT=85.025n

.meas tran vdout1_2ck160 FIND v(dout1_2) AT=85.025n

.meas tran vdout1_3ck160 FIND v(dout1_3) AT=85.025n

.meas tran vdout1_4ck160 FIND v(dout1_4) AT=85.025n

.meas tran vdout1_5ck160 FIND v(dout1_5) AT=85.025n

.meas tran vdout1_6ck160 FIND v(dout1_6) AT=85.025n

.meas tran vdout1_7ck160 FIND v(dout1_7) AT=85.025n

.meas tran vdout1_8ck160 FIND v(dout1_8) AT=85.025n

.meas tran vdout1_9ck160 FIND v(dout1_9) AT=85.025n

.meas tran vdout1_10ck160 FIND v(dout1_10) AT=85.025n

.meas tran vdout1_11ck160 FIND v(dout1_11) AT=85.025n

.meas tran vdout1_12ck160 FIND v(dout1_12) AT=85.025n

.meas tran vdout1_13ck160 FIND v(dout1_13) AT=85.025n

.meas tran vdout1_14ck160 FIND v(dout1_14) AT=85.025n

.meas tran vdout1_15ck160 FIND v(dout1_15) AT=85.025n

.meas tran vdout1_0ck180 FIND v(dout1_0) AT=95.025n

.meas tran vdout1_1ck180 FIND v(dout1_1) AT=95.025n

.meas tran vdout1_2ck180 FIND v(dout1_2) AT=95.025n

.meas tran vdout1_3ck180 FIND v(dout1_3) AT=95.025n

.meas tran vdout1_4ck180 FIND v(dout1_4) AT=95.025n

.meas tran vdout1_5ck180 FIND v(dout1_5) AT=95.025n

.meas tran vdout1_6ck180 FIND v(dout1_6) AT=95.025n

.meas tran vdout1_7ck180 FIND v(dout1_7) AT=95.025n

.meas tran vdout1_8ck180 FIND v(dout1_8) AT=95.025n

.meas tran vdout1_9ck180 FIND v(dout1_9) AT=95.025n

.meas tran vdout1_10ck180 FIND v(dout1_10) AT=95.025n

.meas tran vdout1_11ck180 FIND v(dout1_11) AT=95.025n

.meas tran vdout1_12ck180 FIND v(dout1_12) AT=95.025n

.meas tran vdout1_13ck180 FIND v(dout1_13) AT=95.025n

.meas tran vdout1_14ck180 FIND v(dout1_14) AT=95.025n

.meas tran vdout1_15ck180 FIND v(dout1_15) AT=95.025n

.meas tran vdout1_0ck200 FIND v(dout1_0) AT=105.025n

.meas tran vdout1_1ck200 FIND v(dout1_1) AT=105.025n

.meas tran vdout1_2ck200 FIND v(dout1_2) AT=105.025n

.meas tran vdout1_3ck200 FIND v(dout1_3) AT=105.025n

.meas tran vdout1_4ck200 FIND v(dout1_4) AT=105.025n

.meas tran vdout1_5ck200 FIND v(dout1_5) AT=105.025n

.meas tran vdout1_6ck200 FIND v(dout1_6) AT=105.025n

.meas tran vdout1_7ck200 FIND v(dout1_7) AT=105.025n

.meas tran vdout1_8ck200 FIND v(dout1_8) AT=105.025n

.meas tran vdout1_9ck200 FIND v(dout1_9) AT=105.025n

.meas tran vdout1_10ck200 FIND v(dout1_10) AT=105.025n

.meas tran vdout1_11ck200 FIND v(dout1_11) AT=105.025n

.meas tran vdout1_12ck200 FIND v(dout1_12) AT=105.025n

.meas tran vdout1_13ck200 FIND v(dout1_13) AT=105.025n

.meas tran vdout1_14ck200 FIND v(dout1_14) AT=105.025n

.meas tran vdout1_15ck200 FIND v(dout1_15) AT=105.025n

.meas tran vdout1_0ck210 FIND v(dout1_0) AT=110.025n

.meas tran vdout1_1ck210 FIND v(dout1_1) AT=110.025n

.meas tran vdout1_2ck210 FIND v(dout1_2) AT=110.025n

.meas tran vdout1_3ck210 FIND v(dout1_3) AT=110.025n

.meas tran vdout1_4ck210 FIND v(dout1_4) AT=110.025n

.meas tran vdout1_5ck210 FIND v(dout1_5) AT=110.025n

.meas tran vdout1_6ck210 FIND v(dout1_6) AT=110.025n

.meas tran vdout1_7ck210 FIND v(dout1_7) AT=110.025n

.meas tran vdout1_8ck210 FIND v(dout1_8) AT=110.025n

.meas tran vdout1_9ck210 FIND v(dout1_9) AT=110.025n

.meas tran vdout1_10ck210 FIND v(dout1_10) AT=110.025n

.meas tran vdout1_11ck210 FIND v(dout1_11) AT=110.025n

.meas tran vdout1_12ck210 FIND v(dout1_12) AT=110.025n

.meas tran vdout1_13ck210 FIND v(dout1_13) AT=110.025n

.meas tran vdout1_14ck210 FIND v(dout1_14) AT=110.025n

.meas tran vdout1_15ck210 FIND v(dout1_15) AT=110.025n

.meas tran vdout1_0ck230 FIND v(dout1_0) AT=120.025n

.meas tran vdout1_1ck230 FIND v(dout1_1) AT=120.025n

.meas tran vdout1_2ck230 FIND v(dout1_2) AT=120.025n

.meas tran vdout1_3ck230 FIND v(dout1_3) AT=120.025n

.meas tran vdout1_4ck230 FIND v(dout1_4) AT=120.025n

.meas tran vdout1_5ck230 FIND v(dout1_5) AT=120.025n

.meas tran vdout1_6ck230 FIND v(dout1_6) AT=120.025n

.meas tran vdout1_7ck230 FIND v(dout1_7) AT=120.025n

.meas tran vdout1_8ck230 FIND v(dout1_8) AT=120.025n

.meas tran vdout1_9ck230 FIND v(dout1_9) AT=120.025n

.meas tran vdout1_10ck230 FIND v(dout1_10) AT=120.025n

.meas tran vdout1_11ck230 FIND v(dout1_11) AT=120.025n

.meas tran vdout1_12ck230 FIND v(dout1_12) AT=120.025n

.meas tran vdout1_13ck230 FIND v(dout1_13) AT=120.025n

.meas tran vdout1_14ck230 FIND v(dout1_14) AT=120.025n

.meas tran vdout1_15ck230 FIND v(dout1_15) AT=120.025n

.meas tran vdout1_0ck240 FIND v(dout1_0) AT=125.025n

.meas tran vdout1_1ck240 FIND v(dout1_1) AT=125.025n

.meas tran vdout1_2ck240 FIND v(dout1_2) AT=125.025n

.meas tran vdout1_3ck240 FIND v(dout1_3) AT=125.025n

.meas tran vdout1_4ck240 FIND v(dout1_4) AT=125.025n

.meas tran vdout1_5ck240 FIND v(dout1_5) AT=125.025n

.meas tran vdout1_6ck240 FIND v(dout1_6) AT=125.025n

.meas tran vdout1_7ck240 FIND v(dout1_7) AT=125.025n

.meas tran vdout1_8ck240 FIND v(dout1_8) AT=125.025n

.meas tran vdout1_9ck240 FIND v(dout1_9) AT=125.025n

.meas tran vdout1_10ck240 FIND v(dout1_10) AT=125.025n

.meas tran vdout1_11ck240 FIND v(dout1_11) AT=125.025n

.meas tran vdout1_12ck240 FIND v(dout1_12) AT=125.025n

.meas tran vdout1_13ck240 FIND v(dout1_13) AT=125.025n

.meas tran vdout1_14ck240 FIND v(dout1_14) AT=125.025n

.meas tran vdout1_15ck240 FIND v(dout1_15) AT=125.025n

.meas tran vdout1_0ck250 FIND v(dout1_0) AT=130.025n

.meas tran vdout1_1ck250 FIND v(dout1_1) AT=130.025n

.meas tran vdout1_2ck250 FIND v(dout1_2) AT=130.025n

.meas tran vdout1_3ck250 FIND v(dout1_3) AT=130.025n

.meas tran vdout1_4ck250 FIND v(dout1_4) AT=130.025n

.meas tran vdout1_5ck250 FIND v(dout1_5) AT=130.025n

.meas tran vdout1_6ck250 FIND v(dout1_6) AT=130.025n

.meas tran vdout1_7ck250 FIND v(dout1_7) AT=130.025n

.meas tran vdout1_8ck250 FIND v(dout1_8) AT=130.025n

.meas tran vdout1_9ck250 FIND v(dout1_9) AT=130.025n

.meas tran vdout1_10ck250 FIND v(dout1_10) AT=130.025n

.meas tran vdout1_11ck250 FIND v(dout1_11) AT=130.025n

.meas tran vdout1_12ck250 FIND v(dout1_12) AT=130.025n

.meas tran vdout1_13ck250 FIND v(dout1_13) AT=130.025n

.meas tran vdout1_14ck250 FIND v(dout1_14) AT=130.025n

.meas tran vdout1_15ck250 FIND v(dout1_15) AT=130.025n

.meas tran vdout1_0ck290 FIND v(dout1_0) AT=150.025n

.meas tran vdout1_1ck290 FIND v(dout1_1) AT=150.025n

.meas tran vdout1_2ck290 FIND v(dout1_2) AT=150.025n

.meas tran vdout1_3ck290 FIND v(dout1_3) AT=150.025n

.meas tran vdout1_4ck290 FIND v(dout1_4) AT=150.025n

.meas tran vdout1_5ck290 FIND v(dout1_5) AT=150.025n

.meas tran vdout1_6ck290 FIND v(dout1_6) AT=150.025n

.meas tran vdout1_7ck290 FIND v(dout1_7) AT=150.025n

.meas tran vdout1_8ck290 FIND v(dout1_8) AT=150.025n

.meas tran vdout1_9ck290 FIND v(dout1_9) AT=150.025n

.meas tran vdout1_10ck290 FIND v(dout1_10) AT=150.025n

.meas tran vdout1_11ck290 FIND v(dout1_11) AT=150.025n

.meas tran vdout1_12ck290 FIND v(dout1_12) AT=150.025n

.meas tran vdout1_13ck290 FIND v(dout1_13) AT=150.025n

.meas tran vdout1_14ck290 FIND v(dout1_14) AT=150.025n

.meas tran vdout1_15ck290 FIND v(dout1_15) AT=150.025n

.meas tran vdout1_0ck310 FIND v(dout1_0) AT=160.025n

.meas tran vdout1_1ck310 FIND v(dout1_1) AT=160.025n

.meas tran vdout1_2ck310 FIND v(dout1_2) AT=160.025n

.meas tran vdout1_3ck310 FIND v(dout1_3) AT=160.025n

.meas tran vdout1_4ck310 FIND v(dout1_4) AT=160.025n

.meas tran vdout1_5ck310 FIND v(dout1_5) AT=160.025n

.meas tran vdout1_6ck310 FIND v(dout1_6) AT=160.025n

.meas tran vdout1_7ck310 FIND v(dout1_7) AT=160.025n

.meas tran vdout1_8ck310 FIND v(dout1_8) AT=160.025n

.meas tran vdout1_9ck310 FIND v(dout1_9) AT=160.025n

.meas tran vdout1_10ck310 FIND v(dout1_10) AT=160.025n

.meas tran vdout1_11ck310 FIND v(dout1_11) AT=160.025n

.meas tran vdout1_12ck310 FIND v(dout1_12) AT=160.025n

.meas tran vdout1_13ck310 FIND v(dout1_13) AT=160.025n

.meas tran vdout1_14ck310 FIND v(dout1_14) AT=160.025n

.meas tran vdout1_15ck310 FIND v(dout1_15) AT=160.025n

.meas tran vdout1_0ck330 FIND v(dout1_0) AT=170.025n

.meas tran vdout1_1ck330 FIND v(dout1_1) AT=170.025n

.meas tran vdout1_2ck330 FIND v(dout1_2) AT=170.025n

.meas tran vdout1_3ck330 FIND v(dout1_3) AT=170.025n

.meas tran vdout1_4ck330 FIND v(dout1_4) AT=170.025n

.meas tran vdout1_5ck330 FIND v(dout1_5) AT=170.025n

.meas tran vdout1_6ck330 FIND v(dout1_6) AT=170.025n

.meas tran vdout1_7ck330 FIND v(dout1_7) AT=170.025n

.meas tran vdout1_8ck330 FIND v(dout1_8) AT=170.025n

.meas tran vdout1_9ck330 FIND v(dout1_9) AT=170.025n

.meas tran vdout1_10ck330 FIND v(dout1_10) AT=170.025n

.meas tran vdout1_11ck330 FIND v(dout1_11) AT=170.025n

.meas tran vdout1_12ck330 FIND v(dout1_12) AT=170.025n

.meas tran vdout1_13ck330 FIND v(dout1_13) AT=170.025n

.meas tran vdout1_14ck330 FIND v(dout1_14) AT=170.025n

.meas tran vdout1_15ck330 FIND v(dout1_15) AT=170.025n

.meas tran vdout1_0ck360 FIND v(dout1_0) AT=185.025n

.meas tran vdout1_1ck360 FIND v(dout1_1) AT=185.025n

.meas tran vdout1_2ck360 FIND v(dout1_2) AT=185.025n

.meas tran vdout1_3ck360 FIND v(dout1_3) AT=185.025n

.meas tran vdout1_4ck360 FIND v(dout1_4) AT=185.025n

.meas tran vdout1_5ck360 FIND v(dout1_5) AT=185.025n

.meas tran vdout1_6ck360 FIND v(dout1_6) AT=185.025n

.meas tran vdout1_7ck360 FIND v(dout1_7) AT=185.025n

.meas tran vdout1_8ck360 FIND v(dout1_8) AT=185.025n

.meas tran vdout1_9ck360 FIND v(dout1_9) AT=185.025n

.meas tran vdout1_10ck360 FIND v(dout1_10) AT=185.025n

.meas tran vdout1_11ck360 FIND v(dout1_11) AT=185.025n

.meas tran vdout1_12ck360 FIND v(dout1_12) AT=185.025n

.meas tran vdout1_13ck360 FIND v(dout1_13) AT=185.025n

.meas tran vdout1_14ck360 FIND v(dout1_14) AT=185.025n

.meas tran vdout1_15ck360 FIND v(dout1_15) AT=185.025n

.meas tran vdout1_0ck390 FIND v(dout1_0) AT=200.025n

.meas tran vdout1_1ck390 FIND v(dout1_1) AT=200.025n

.meas tran vdout1_2ck390 FIND v(dout1_2) AT=200.025n

.meas tran vdout1_3ck390 FIND v(dout1_3) AT=200.025n

.meas tran vdout1_4ck390 FIND v(dout1_4) AT=200.025n

.meas tran vdout1_5ck390 FIND v(dout1_5) AT=200.025n

.meas tran vdout1_6ck390 FIND v(dout1_6) AT=200.025n

.meas tran vdout1_7ck390 FIND v(dout1_7) AT=200.025n

.meas tran vdout1_8ck390 FIND v(dout1_8) AT=200.025n

.meas tran vdout1_9ck390 FIND v(dout1_9) AT=200.025n

.meas tran vdout1_10ck390 FIND v(dout1_10) AT=200.025n

.meas tran vdout1_11ck390 FIND v(dout1_11) AT=200.025n

.meas tran vdout1_12ck390 FIND v(dout1_12) AT=200.025n

.meas tran vdout1_13ck390 FIND v(dout1_13) AT=200.025n

.meas tran vdout1_14ck390 FIND v(dout1_14) AT=200.025n

.meas tran vdout1_15ck390 FIND v(dout1_15) AT=200.025n

.meas tran vdout1_0ck410 FIND v(dout1_0) AT=210.025n

.meas tran vdout1_1ck410 FIND v(dout1_1) AT=210.025n

.meas tran vdout1_2ck410 FIND v(dout1_2) AT=210.025n

.meas tran vdout1_3ck410 FIND v(dout1_3) AT=210.025n

.meas tran vdout1_4ck410 FIND v(dout1_4) AT=210.025n

.meas tran vdout1_5ck410 FIND v(dout1_5) AT=210.025n

.meas tran vdout1_6ck410 FIND v(dout1_6) AT=210.025n

.meas tran vdout1_7ck410 FIND v(dout1_7) AT=210.025n

.meas tran vdout1_8ck410 FIND v(dout1_8) AT=210.025n

.meas tran vdout1_9ck410 FIND v(dout1_9) AT=210.025n

.meas tran vdout1_10ck410 FIND v(dout1_10) AT=210.025n

.meas tran vdout1_11ck410 FIND v(dout1_11) AT=210.025n

.meas tran vdout1_12ck410 FIND v(dout1_12) AT=210.025n

.meas tran vdout1_13ck410 FIND v(dout1_13) AT=210.025n

.meas tran vdout1_14ck410 FIND v(dout1_14) AT=210.025n

.meas tran vdout1_15ck410 FIND v(dout1_15) AT=210.025n

.meas tran vdout1_0ck420 FIND v(dout1_0) AT=215.025n

.meas tran vdout1_1ck420 FIND v(dout1_1) AT=215.025n

.meas tran vdout1_2ck420 FIND v(dout1_2) AT=215.025n

.meas tran vdout1_3ck420 FIND v(dout1_3) AT=215.025n

.meas tran vdout1_4ck420 FIND v(dout1_4) AT=215.025n

.meas tran vdout1_5ck420 FIND v(dout1_5) AT=215.025n

.meas tran vdout1_6ck420 FIND v(dout1_6) AT=215.025n

.meas tran vdout1_7ck420 FIND v(dout1_7) AT=215.025n

.meas tran vdout1_8ck420 FIND v(dout1_8) AT=215.025n

.meas tran vdout1_9ck420 FIND v(dout1_9) AT=215.025n

.meas tran vdout1_10ck420 FIND v(dout1_10) AT=215.025n

.meas tran vdout1_11ck420 FIND v(dout1_11) AT=215.025n

.meas tran vdout1_12ck420 FIND v(dout1_12) AT=215.025n

.meas tran vdout1_13ck420 FIND v(dout1_13) AT=215.025n

.meas tran vdout1_14ck420 FIND v(dout1_14) AT=215.025n

.meas tran vdout1_15ck420 FIND v(dout1_15) AT=215.025n

.meas tran vdout1_0ck440 FIND v(dout1_0) AT=225.025n

.meas tran vdout1_1ck440 FIND v(dout1_1) AT=225.025n

.meas tran vdout1_2ck440 FIND v(dout1_2) AT=225.025n

.meas tran vdout1_3ck440 FIND v(dout1_3) AT=225.025n

.meas tran vdout1_4ck440 FIND v(dout1_4) AT=225.025n

.meas tran vdout1_5ck440 FIND v(dout1_5) AT=225.025n

.meas tran vdout1_6ck440 FIND v(dout1_6) AT=225.025n

.meas tran vdout1_7ck440 FIND v(dout1_7) AT=225.025n

.meas tran vdout1_8ck440 FIND v(dout1_8) AT=225.025n

.meas tran vdout1_9ck440 FIND v(dout1_9) AT=225.025n

.meas tran vdout1_10ck440 FIND v(dout1_10) AT=225.025n

.meas tran vdout1_11ck440 FIND v(dout1_11) AT=225.025n

.meas tran vdout1_12ck440 FIND v(dout1_12) AT=225.025n

.meas tran vdout1_13ck440 FIND v(dout1_13) AT=225.025n

.meas tran vdout1_14ck440 FIND v(dout1_14) AT=225.025n

.meas tran vdout1_15ck440 FIND v(dout1_15) AT=225.025n

.meas tran vdout1_0ck460 FIND v(dout1_0) AT=235.025n

.meas tran vdout1_1ck460 FIND v(dout1_1) AT=235.025n

.meas tran vdout1_2ck460 FIND v(dout1_2) AT=235.025n

.meas tran vdout1_3ck460 FIND v(dout1_3) AT=235.025n

.meas tran vdout1_4ck460 FIND v(dout1_4) AT=235.025n

.meas tran vdout1_5ck460 FIND v(dout1_5) AT=235.025n

.meas tran vdout1_6ck460 FIND v(dout1_6) AT=235.025n

.meas tran vdout1_7ck460 FIND v(dout1_7) AT=235.025n

.meas tran vdout1_8ck460 FIND v(dout1_8) AT=235.025n

.meas tran vdout1_9ck460 FIND v(dout1_9) AT=235.025n

.meas tran vdout1_10ck460 FIND v(dout1_10) AT=235.025n

.meas tran vdout1_11ck460 FIND v(dout1_11) AT=235.025n

.meas tran vdout1_12ck460 FIND v(dout1_12) AT=235.025n

.meas tran vdout1_13ck460 FIND v(dout1_13) AT=235.025n

.meas tran vdout1_14ck460 FIND v(dout1_14) AT=235.025n

.meas tran vdout1_15ck460 FIND v(dout1_15) AT=235.025n

.meas tran vdout1_0ck490 FIND v(dout1_0) AT=250.025n

.meas tran vdout1_1ck490 FIND v(dout1_1) AT=250.025n

.meas tran vdout1_2ck490 FIND v(dout1_2) AT=250.025n

.meas tran vdout1_3ck490 FIND v(dout1_3) AT=250.025n

.meas tran vdout1_4ck490 FIND v(dout1_4) AT=250.025n

.meas tran vdout1_5ck490 FIND v(dout1_5) AT=250.025n

.meas tran vdout1_6ck490 FIND v(dout1_6) AT=250.025n

.meas tran vdout1_7ck490 FIND v(dout1_7) AT=250.025n

.meas tran vdout1_8ck490 FIND v(dout1_8) AT=250.025n

.meas tran vdout1_9ck490 FIND v(dout1_9) AT=250.025n

.meas tran vdout1_10ck490 FIND v(dout1_10) AT=250.025n

.meas tran vdout1_11ck490 FIND v(dout1_11) AT=250.025n

.meas tran vdout1_12ck490 FIND v(dout1_12) AT=250.025n

.meas tran vdout1_13ck490 FIND v(dout1_13) AT=250.025n

.meas tran vdout1_14ck490 FIND v(dout1_14) AT=250.025n

.meas tran vdout1_15ck490 FIND v(dout1_15) AT=250.025n

.meas tran vdout1_0ck500 FIND v(dout1_0) AT=255.025n

.meas tran vdout1_1ck500 FIND v(dout1_1) AT=255.025n

.meas tran vdout1_2ck500 FIND v(dout1_2) AT=255.025n

.meas tran vdout1_3ck500 FIND v(dout1_3) AT=255.025n

.meas tran vdout1_4ck500 FIND v(dout1_4) AT=255.025n

.meas tran vdout1_5ck500 FIND v(dout1_5) AT=255.025n

.meas tran vdout1_6ck500 FIND v(dout1_6) AT=255.025n

.meas tran vdout1_7ck500 FIND v(dout1_7) AT=255.025n

.meas tran vdout1_8ck500 FIND v(dout1_8) AT=255.025n

.meas tran vdout1_9ck500 FIND v(dout1_9) AT=255.025n

.meas tran vdout1_10ck500 FIND v(dout1_10) AT=255.025n

.meas tran vdout1_11ck500 FIND v(dout1_11) AT=255.025n

.meas tran vdout1_12ck500 FIND v(dout1_12) AT=255.025n

.meas tran vdout1_13ck500 FIND v(dout1_13) AT=255.025n

.meas tran vdout1_14ck500 FIND v(dout1_14) AT=255.025n

.meas tran vdout1_15ck500 FIND v(dout1_15) AT=255.025n

.meas tran vdout1_0ck520 FIND v(dout1_0) AT=265.025n

.meas tran vdout1_1ck520 FIND v(dout1_1) AT=265.025n

.meas tran vdout1_2ck520 FIND v(dout1_2) AT=265.025n

.meas tran vdout1_3ck520 FIND v(dout1_3) AT=265.025n

.meas tran vdout1_4ck520 FIND v(dout1_4) AT=265.025n

.meas tran vdout1_5ck520 FIND v(dout1_5) AT=265.025n

.meas tran vdout1_6ck520 FIND v(dout1_6) AT=265.025n

.meas tran vdout1_7ck520 FIND v(dout1_7) AT=265.025n

.meas tran vdout1_8ck520 FIND v(dout1_8) AT=265.025n

.meas tran vdout1_9ck520 FIND v(dout1_9) AT=265.025n

.meas tran vdout1_10ck520 FIND v(dout1_10) AT=265.025n

.meas tran vdout1_11ck520 FIND v(dout1_11) AT=265.025n

.meas tran vdout1_12ck520 FIND v(dout1_12) AT=265.025n

.meas tran vdout1_13ck520 FIND v(dout1_13) AT=265.025n

.meas tran vdout1_14ck520 FIND v(dout1_14) AT=265.025n

.meas tran vdout1_15ck520 FIND v(dout1_15) AT=265.025n

.meas tran vdout1_0ck530 FIND v(dout1_0) AT=270.025n

.meas tran vdout1_1ck530 FIND v(dout1_1) AT=270.025n

.meas tran vdout1_2ck530 FIND v(dout1_2) AT=270.025n

.meas tran vdout1_3ck530 FIND v(dout1_3) AT=270.025n

.meas tran vdout1_4ck530 FIND v(dout1_4) AT=270.025n

.meas tran vdout1_5ck530 FIND v(dout1_5) AT=270.025n

.meas tran vdout1_6ck530 FIND v(dout1_6) AT=270.025n

.meas tran vdout1_7ck530 FIND v(dout1_7) AT=270.025n

.meas tran vdout1_8ck530 FIND v(dout1_8) AT=270.025n

.meas tran vdout1_9ck530 FIND v(dout1_9) AT=270.025n

.meas tran vdout1_10ck530 FIND v(dout1_10) AT=270.025n

.meas tran vdout1_11ck530 FIND v(dout1_11) AT=270.025n

.meas tran vdout1_12ck530 FIND v(dout1_12) AT=270.025n

.meas tran vdout1_13ck530 FIND v(dout1_13) AT=270.025n

.meas tran vdout1_14ck530 FIND v(dout1_14) AT=270.025n

.meas tran vdout1_15ck530 FIND v(dout1_15) AT=270.025n

.meas tran vdout1_0ck540 FIND v(dout1_0) AT=275.025n

.meas tran vdout1_1ck540 FIND v(dout1_1) AT=275.025n

.meas tran vdout1_2ck540 FIND v(dout1_2) AT=275.025n

.meas tran vdout1_3ck540 FIND v(dout1_3) AT=275.025n

.meas tran vdout1_4ck540 FIND v(dout1_4) AT=275.025n

.meas tran vdout1_5ck540 FIND v(dout1_5) AT=275.025n

.meas tran vdout1_6ck540 FIND v(dout1_6) AT=275.025n

.meas tran vdout1_7ck540 FIND v(dout1_7) AT=275.025n

.meas tran vdout1_8ck540 FIND v(dout1_8) AT=275.025n

.meas tran vdout1_9ck540 FIND v(dout1_9) AT=275.025n

.meas tran vdout1_10ck540 FIND v(dout1_10) AT=275.025n

.meas tran vdout1_11ck540 FIND v(dout1_11) AT=275.025n

.meas tran vdout1_12ck540 FIND v(dout1_12) AT=275.025n

.meas tran vdout1_13ck540 FIND v(dout1_13) AT=275.025n

.meas tran vdout1_14ck540 FIND v(dout1_14) AT=275.025n

.meas tran vdout1_15ck540 FIND v(dout1_15) AT=275.025n

.meas tran vdout1_0ck550 FIND v(dout1_0) AT=280.025n

.meas tran vdout1_1ck550 FIND v(dout1_1) AT=280.025n

.meas tran vdout1_2ck550 FIND v(dout1_2) AT=280.025n

.meas tran vdout1_3ck550 FIND v(dout1_3) AT=280.025n

.meas tran vdout1_4ck550 FIND v(dout1_4) AT=280.025n

.meas tran vdout1_5ck550 FIND v(dout1_5) AT=280.025n

.meas tran vdout1_6ck550 FIND v(dout1_6) AT=280.025n

.meas tran vdout1_7ck550 FIND v(dout1_7) AT=280.025n

.meas tran vdout1_8ck550 FIND v(dout1_8) AT=280.025n

.meas tran vdout1_9ck550 FIND v(dout1_9) AT=280.025n

.meas tran vdout1_10ck550 FIND v(dout1_10) AT=280.025n

.meas tran vdout1_11ck550 FIND v(dout1_11) AT=280.025n

.meas tran vdout1_12ck550 FIND v(dout1_12) AT=280.025n

.meas tran vdout1_13ck550 FIND v(dout1_13) AT=280.025n

.meas tran vdout1_14ck550 FIND v(dout1_14) AT=280.025n

.meas tran vdout1_15ck550 FIND v(dout1_15) AT=280.025n

.meas tran vdout1_0ck570 FIND v(dout1_0) AT=290.025n

.meas tran vdout1_1ck570 FIND v(dout1_1) AT=290.025n

.meas tran vdout1_2ck570 FIND v(dout1_2) AT=290.025n

.meas tran vdout1_3ck570 FIND v(dout1_3) AT=290.025n

.meas tran vdout1_4ck570 FIND v(dout1_4) AT=290.025n

.meas tran vdout1_5ck570 FIND v(dout1_5) AT=290.025n

.meas tran vdout1_6ck570 FIND v(dout1_6) AT=290.025n

.meas tran vdout1_7ck570 FIND v(dout1_7) AT=290.025n

.meas tran vdout1_8ck570 FIND v(dout1_8) AT=290.025n

.meas tran vdout1_9ck570 FIND v(dout1_9) AT=290.025n

.meas tran vdout1_10ck570 FIND v(dout1_10) AT=290.025n

.meas tran vdout1_11ck570 FIND v(dout1_11) AT=290.025n

.meas tran vdout1_12ck570 FIND v(dout1_12) AT=290.025n

.meas tran vdout1_13ck570 FIND v(dout1_13) AT=290.025n

.meas tran vdout1_14ck570 FIND v(dout1_14) AT=290.025n

.meas tran vdout1_15ck570 FIND v(dout1_15) AT=290.025n

.meas tran vdout1_0ck590 FIND v(dout1_0) AT=300.025n

.meas tran vdout1_1ck590 FIND v(dout1_1) AT=300.025n

.meas tran vdout1_2ck590 FIND v(dout1_2) AT=300.025n

.meas tran vdout1_3ck590 FIND v(dout1_3) AT=300.025n

.meas tran vdout1_4ck590 FIND v(dout1_4) AT=300.025n

.meas tran vdout1_5ck590 FIND v(dout1_5) AT=300.025n

.meas tran vdout1_6ck590 FIND v(dout1_6) AT=300.025n

.meas tran vdout1_7ck590 FIND v(dout1_7) AT=300.025n

.meas tran vdout1_8ck590 FIND v(dout1_8) AT=300.025n

.meas tran vdout1_9ck590 FIND v(dout1_9) AT=300.025n

.meas tran vdout1_10ck590 FIND v(dout1_10) AT=300.025n

.meas tran vdout1_11ck590 FIND v(dout1_11) AT=300.025n

.meas tran vdout1_12ck590 FIND v(dout1_12) AT=300.025n

.meas tran vdout1_13ck590 FIND v(dout1_13) AT=300.025n

.meas tran vdout1_14ck590 FIND v(dout1_14) AT=300.025n

.meas tran vdout1_15ck590 FIND v(dout1_15) AT=300.025n

.meas tran vdout1_0ck640 FIND v(dout1_0) AT=325.025n

.meas tran vdout1_1ck640 FIND v(dout1_1) AT=325.025n

.meas tran vdout1_2ck640 FIND v(dout1_2) AT=325.025n

.meas tran vdout1_3ck640 FIND v(dout1_3) AT=325.025n

.meas tran vdout1_4ck640 FIND v(dout1_4) AT=325.025n

.meas tran vdout1_5ck640 FIND v(dout1_5) AT=325.025n

.meas tran vdout1_6ck640 FIND v(dout1_6) AT=325.025n

.meas tran vdout1_7ck640 FIND v(dout1_7) AT=325.025n

.meas tran vdout1_8ck640 FIND v(dout1_8) AT=325.025n

.meas tran vdout1_9ck640 FIND v(dout1_9) AT=325.025n

.meas tran vdout1_10ck640 FIND v(dout1_10) AT=325.025n

.meas tran vdout1_11ck640 FIND v(dout1_11) AT=325.025n

.meas tran vdout1_12ck640 FIND v(dout1_12) AT=325.025n

.meas tran vdout1_13ck640 FIND v(dout1_13) AT=325.025n

.meas tran vdout1_14ck640 FIND v(dout1_14) AT=325.025n

.meas tran vdout1_15ck640 FIND v(dout1_15) AT=325.025n

.meas tran vdout1_0ck650 FIND v(dout1_0) AT=330.025n

.meas tran vdout1_1ck650 FIND v(dout1_1) AT=330.025n

.meas tran vdout1_2ck650 FIND v(dout1_2) AT=330.025n

.meas tran vdout1_3ck650 FIND v(dout1_3) AT=330.025n

.meas tran vdout1_4ck650 FIND v(dout1_4) AT=330.025n

.meas tran vdout1_5ck650 FIND v(dout1_5) AT=330.025n

.meas tran vdout1_6ck650 FIND v(dout1_6) AT=330.025n

.meas tran vdout1_7ck650 FIND v(dout1_7) AT=330.025n

.meas tran vdout1_8ck650 FIND v(dout1_8) AT=330.025n

.meas tran vdout1_9ck650 FIND v(dout1_9) AT=330.025n

.meas tran vdout1_10ck650 FIND v(dout1_10) AT=330.025n

.meas tran vdout1_11ck650 FIND v(dout1_11) AT=330.025n

.meas tran vdout1_12ck650 FIND v(dout1_12) AT=330.025n

.meas tran vdout1_13ck650 FIND v(dout1_13) AT=330.025n

.meas tran vdout1_14ck650 FIND v(dout1_14) AT=330.025n

.meas tran vdout1_15ck650 FIND v(dout1_15) AT=330.025n

.meas tran vdout1_0ck660 FIND v(dout1_0) AT=335.025n

.meas tran vdout1_1ck660 FIND v(dout1_1) AT=335.025n

.meas tran vdout1_2ck660 FIND v(dout1_2) AT=335.025n

.meas tran vdout1_3ck660 FIND v(dout1_3) AT=335.025n

.meas tran vdout1_4ck660 FIND v(dout1_4) AT=335.025n

.meas tran vdout1_5ck660 FIND v(dout1_5) AT=335.025n

.meas tran vdout1_6ck660 FIND v(dout1_6) AT=335.025n

.meas tran vdout1_7ck660 FIND v(dout1_7) AT=335.025n

.meas tran vdout1_8ck660 FIND v(dout1_8) AT=335.025n

.meas tran vdout1_9ck660 FIND v(dout1_9) AT=335.025n

.meas tran vdout1_10ck660 FIND v(dout1_10) AT=335.025n

.meas tran vdout1_11ck660 FIND v(dout1_11) AT=335.025n

.meas tran vdout1_12ck660 FIND v(dout1_12) AT=335.025n

.meas tran vdout1_13ck660 FIND v(dout1_13) AT=335.025n

.meas tran vdout1_14ck660 FIND v(dout1_14) AT=335.025n

.meas tran vdout1_15ck660 FIND v(dout1_15) AT=335.025n

.meas tran vdout1_0ck720 FIND v(dout1_0) AT=365.025n

.meas tran vdout1_1ck720 FIND v(dout1_1) AT=365.025n

.meas tran vdout1_2ck720 FIND v(dout1_2) AT=365.025n

.meas tran vdout1_3ck720 FIND v(dout1_3) AT=365.025n

.meas tran vdout1_4ck720 FIND v(dout1_4) AT=365.025n

.meas tran vdout1_5ck720 FIND v(dout1_5) AT=365.025n

.meas tran vdout1_6ck720 FIND v(dout1_6) AT=365.025n

.meas tran vdout1_7ck720 FIND v(dout1_7) AT=365.025n

.meas tran vdout1_8ck720 FIND v(dout1_8) AT=365.025n

.meas tran vdout1_9ck720 FIND v(dout1_9) AT=365.025n

.meas tran vdout1_10ck720 FIND v(dout1_10) AT=365.025n

.meas tran vdout1_11ck720 FIND v(dout1_11) AT=365.025n

.meas tran vdout1_12ck720 FIND v(dout1_12) AT=365.025n

.meas tran vdout1_13ck720 FIND v(dout1_13) AT=365.025n

.meas tran vdout1_14ck720 FIND v(dout1_14) AT=365.025n

.meas tran vdout1_15ck720 FIND v(dout1_15) AT=365.025n

.meas tran vdout1_0ck740 FIND v(dout1_0) AT=375.025n

.meas tran vdout1_1ck740 FIND v(dout1_1) AT=375.025n

.meas tran vdout1_2ck740 FIND v(dout1_2) AT=375.025n

.meas tran vdout1_3ck740 FIND v(dout1_3) AT=375.025n

.meas tran vdout1_4ck740 FIND v(dout1_4) AT=375.025n

.meas tran vdout1_5ck740 FIND v(dout1_5) AT=375.025n

.meas tran vdout1_6ck740 FIND v(dout1_6) AT=375.025n

.meas tran vdout1_7ck740 FIND v(dout1_7) AT=375.025n

.meas tran vdout1_8ck740 FIND v(dout1_8) AT=375.025n

.meas tran vdout1_9ck740 FIND v(dout1_9) AT=375.025n

.meas tran vdout1_10ck740 FIND v(dout1_10) AT=375.025n

.meas tran vdout1_11ck740 FIND v(dout1_11) AT=375.025n

.meas tran vdout1_12ck740 FIND v(dout1_12) AT=375.025n

.meas tran vdout1_13ck740 FIND v(dout1_13) AT=375.025n

.meas tran vdout1_14ck740 FIND v(dout1_14) AT=375.025n

.meas tran vdout1_15ck740 FIND v(dout1_15) AT=375.025n

.meas tran vdout1_0ck820 FIND v(dout1_0) AT=415.025n

.meas tran vdout1_1ck820 FIND v(dout1_1) AT=415.025n

.meas tran vdout1_2ck820 FIND v(dout1_2) AT=415.025n

.meas tran vdout1_3ck820 FIND v(dout1_3) AT=415.025n

.meas tran vdout1_4ck820 FIND v(dout1_4) AT=415.025n

.meas tran vdout1_5ck820 FIND v(dout1_5) AT=415.025n

.meas tran vdout1_6ck820 FIND v(dout1_6) AT=415.025n

.meas tran vdout1_7ck820 FIND v(dout1_7) AT=415.025n

.meas tran vdout1_8ck820 FIND v(dout1_8) AT=415.025n

.meas tran vdout1_9ck820 FIND v(dout1_9) AT=415.025n

.meas tran vdout1_10ck820 FIND v(dout1_10) AT=415.025n

.meas tran vdout1_11ck820 FIND v(dout1_11) AT=415.025n

.meas tran vdout1_12ck820 FIND v(dout1_12) AT=415.025n

.meas tran vdout1_13ck820 FIND v(dout1_13) AT=415.025n

.meas tran vdout1_14ck820 FIND v(dout1_14) AT=415.025n

.meas tran vdout1_15ck820 FIND v(dout1_15) AT=415.025n

.meas tran vdout1_0ck860 FIND v(dout1_0) AT=435.025n

.meas tran vdout1_1ck860 FIND v(dout1_1) AT=435.025n

.meas tran vdout1_2ck860 FIND v(dout1_2) AT=435.025n

.meas tran vdout1_3ck860 FIND v(dout1_3) AT=435.025n

.meas tran vdout1_4ck860 FIND v(dout1_4) AT=435.025n

.meas tran vdout1_5ck860 FIND v(dout1_5) AT=435.025n

.meas tran vdout1_6ck860 FIND v(dout1_6) AT=435.025n

.meas tran vdout1_7ck860 FIND v(dout1_7) AT=435.025n

.meas tran vdout1_8ck860 FIND v(dout1_8) AT=435.025n

.meas tran vdout1_9ck860 FIND v(dout1_9) AT=435.025n

.meas tran vdout1_10ck860 FIND v(dout1_10) AT=435.025n

.meas tran vdout1_11ck860 FIND v(dout1_11) AT=435.025n

.meas tran vdout1_12ck860 FIND v(dout1_12) AT=435.025n

.meas tran vdout1_13ck860 FIND v(dout1_13) AT=435.025n

.meas tran vdout1_14ck860 FIND v(dout1_14) AT=435.025n

.meas tran vdout1_15ck860 FIND v(dout1_15) AT=435.025n

.meas tran vdout1_0ck890 FIND v(dout1_0) AT=450.025n

.meas tran vdout1_1ck890 FIND v(dout1_1) AT=450.025n

.meas tran vdout1_2ck890 FIND v(dout1_2) AT=450.025n

.meas tran vdout1_3ck890 FIND v(dout1_3) AT=450.025n

.meas tran vdout1_4ck890 FIND v(dout1_4) AT=450.025n

.meas tran vdout1_5ck890 FIND v(dout1_5) AT=450.025n

.meas tran vdout1_6ck890 FIND v(dout1_6) AT=450.025n

.meas tran vdout1_7ck890 FIND v(dout1_7) AT=450.025n

.meas tran vdout1_8ck890 FIND v(dout1_8) AT=450.025n

.meas tran vdout1_9ck890 FIND v(dout1_9) AT=450.025n

.meas tran vdout1_10ck890 FIND v(dout1_10) AT=450.025n

.meas tran vdout1_11ck890 FIND v(dout1_11) AT=450.025n

.meas tran vdout1_12ck890 FIND v(dout1_12) AT=450.025n

.meas tran vdout1_13ck890 FIND v(dout1_13) AT=450.025n

.meas tran vdout1_14ck890 FIND v(dout1_14) AT=450.025n

.meas tran vdout1_15ck890 FIND v(dout1_15) AT=450.025n

.meas tran vdout1_0ck910 FIND v(dout1_0) AT=460.025n

.meas tran vdout1_1ck910 FIND v(dout1_1) AT=460.025n

.meas tran vdout1_2ck910 FIND v(dout1_2) AT=460.025n

.meas tran vdout1_3ck910 FIND v(dout1_3) AT=460.025n

.meas tran vdout1_4ck910 FIND v(dout1_4) AT=460.025n

.meas tran vdout1_5ck910 FIND v(dout1_5) AT=460.025n

.meas tran vdout1_6ck910 FIND v(dout1_6) AT=460.025n

.meas tran vdout1_7ck910 FIND v(dout1_7) AT=460.025n

.meas tran vdout1_8ck910 FIND v(dout1_8) AT=460.025n

.meas tran vdout1_9ck910 FIND v(dout1_9) AT=460.025n

.meas tran vdout1_10ck910 FIND v(dout1_10) AT=460.025n

.meas tran vdout1_11ck910 FIND v(dout1_11) AT=460.025n

.meas tran vdout1_12ck910 FIND v(dout1_12) AT=460.025n

.meas tran vdout1_13ck910 FIND v(dout1_13) AT=460.025n

.meas tran vdout1_14ck910 FIND v(dout1_14) AT=460.025n

.meas tran vdout1_15ck910 FIND v(dout1_15) AT=460.025n

.meas tran vdout1_0ck920 FIND v(dout1_0) AT=465.025n

.meas tran vdout1_1ck920 FIND v(dout1_1) AT=465.025n

.meas tran vdout1_2ck920 FIND v(dout1_2) AT=465.025n

.meas tran vdout1_3ck920 FIND v(dout1_3) AT=465.025n

.meas tran vdout1_4ck920 FIND v(dout1_4) AT=465.025n

.meas tran vdout1_5ck920 FIND v(dout1_5) AT=465.025n

.meas tran vdout1_6ck920 FIND v(dout1_6) AT=465.025n

.meas tran vdout1_7ck920 FIND v(dout1_7) AT=465.025n

.meas tran vdout1_8ck920 FIND v(dout1_8) AT=465.025n

.meas tran vdout1_9ck920 FIND v(dout1_9) AT=465.025n

.meas tran vdout1_10ck920 FIND v(dout1_10) AT=465.025n

.meas tran vdout1_11ck920 FIND v(dout1_11) AT=465.025n

.meas tran vdout1_12ck920 FIND v(dout1_12) AT=465.025n

.meas tran vdout1_13ck920 FIND v(dout1_13) AT=465.025n

.meas tran vdout1_14ck920 FIND v(dout1_14) AT=465.025n

.meas tran vdout1_15ck920 FIND v(dout1_15) AT=465.025n

.meas tran vdout1_0ck960 FIND v(dout1_0) AT=485.025n

.meas tran vdout1_1ck960 FIND v(dout1_1) AT=485.025n

.meas tran vdout1_2ck960 FIND v(dout1_2) AT=485.025n

.meas tran vdout1_3ck960 FIND v(dout1_3) AT=485.025n

.meas tran vdout1_4ck960 FIND v(dout1_4) AT=485.025n

.meas tran vdout1_5ck960 FIND v(dout1_5) AT=485.025n

.meas tran vdout1_6ck960 FIND v(dout1_6) AT=485.025n

.meas tran vdout1_7ck960 FIND v(dout1_7) AT=485.025n

.meas tran vdout1_8ck960 FIND v(dout1_8) AT=485.025n

.meas tran vdout1_9ck960 FIND v(dout1_9) AT=485.025n

.meas tran vdout1_10ck960 FIND v(dout1_10) AT=485.025n

.meas tran vdout1_11ck960 FIND v(dout1_11) AT=485.025n

.meas tran vdout1_12ck960 FIND v(dout1_12) AT=485.025n

.meas tran vdout1_13ck960 FIND v(dout1_13) AT=485.025n

.meas tran vdout1_14ck960 FIND v(dout1_14) AT=485.025n

.meas tran vdout1_15ck960 FIND v(dout1_15) AT=485.025n

.meas tran vdout1_0ck970 FIND v(dout1_0) AT=490.025n

.meas tran vdout1_1ck970 FIND v(dout1_1) AT=490.025n

.meas tran vdout1_2ck970 FIND v(dout1_2) AT=490.025n

.meas tran vdout1_3ck970 FIND v(dout1_3) AT=490.025n

.meas tran vdout1_4ck970 FIND v(dout1_4) AT=490.025n

.meas tran vdout1_5ck970 FIND v(dout1_5) AT=490.025n

.meas tran vdout1_6ck970 FIND v(dout1_6) AT=490.025n

.meas tran vdout1_7ck970 FIND v(dout1_7) AT=490.025n

.meas tran vdout1_8ck970 FIND v(dout1_8) AT=490.025n

.meas tran vdout1_9ck970 FIND v(dout1_9) AT=490.025n

.meas tran vdout1_10ck970 FIND v(dout1_10) AT=490.025n

.meas tran vdout1_11ck970 FIND v(dout1_11) AT=490.025n

.meas tran vdout1_12ck970 FIND v(dout1_12) AT=490.025n

.meas tran vdout1_13ck970 FIND v(dout1_13) AT=490.025n

.meas tran vdout1_14ck970 FIND v(dout1_14) AT=490.025n

.meas tran vdout1_15ck970 FIND v(dout1_15) AT=490.025n

.meas tran vdout1_0ck980 FIND v(dout1_0) AT=495.025n

.meas tran vdout1_1ck980 FIND v(dout1_1) AT=495.025n

.meas tran vdout1_2ck980 FIND v(dout1_2) AT=495.025n

.meas tran vdout1_3ck980 FIND v(dout1_3) AT=495.025n

.meas tran vdout1_4ck980 FIND v(dout1_4) AT=495.025n

.meas tran vdout1_5ck980 FIND v(dout1_5) AT=495.025n

.meas tran vdout1_6ck980 FIND v(dout1_6) AT=495.025n

.meas tran vdout1_7ck980 FIND v(dout1_7) AT=495.025n

.meas tran vdout1_8ck980 FIND v(dout1_8) AT=495.025n

.meas tran vdout1_9ck980 FIND v(dout1_9) AT=495.025n

.meas tran vdout1_10ck980 FIND v(dout1_10) AT=495.025n

.meas tran vdout1_11ck980 FIND v(dout1_11) AT=495.025n

.meas tran vdout1_12ck980 FIND v(dout1_12) AT=495.025n

.meas tran vdout1_13ck980 FIND v(dout1_13) AT=495.025n

.meas tran vdout1_14ck980 FIND v(dout1_14) AT=495.025n

.meas tran vdout1_15ck980 FIND v(dout1_15) AT=495.025n

.meas tran vdout1_0ck1030 FIND v(dout1_0) AT=520.025n

.meas tran vdout1_1ck1030 FIND v(dout1_1) AT=520.025n

.meas tran vdout1_2ck1030 FIND v(dout1_2) AT=520.025n

.meas tran vdout1_3ck1030 FIND v(dout1_3) AT=520.025n

.meas tran vdout1_4ck1030 FIND v(dout1_4) AT=520.025n

.meas tran vdout1_5ck1030 FIND v(dout1_5) AT=520.025n

.meas tran vdout1_6ck1030 FIND v(dout1_6) AT=520.025n

.meas tran vdout1_7ck1030 FIND v(dout1_7) AT=520.025n

.meas tran vdout1_8ck1030 FIND v(dout1_8) AT=520.025n

.meas tran vdout1_9ck1030 FIND v(dout1_9) AT=520.025n

.meas tran vdout1_10ck1030 FIND v(dout1_10) AT=520.025n

.meas tran vdout1_11ck1030 FIND v(dout1_11) AT=520.025n

.meas tran vdout1_12ck1030 FIND v(dout1_12) AT=520.025n

.meas tran vdout1_13ck1030 FIND v(dout1_13) AT=520.025n

.meas tran vdout1_14ck1030 FIND v(dout1_14) AT=520.025n

.meas tran vdout1_15ck1030 FIND v(dout1_15) AT=520.025n

.meas tran vdout1_0ck1060 FIND v(dout1_0) AT=535.025n

.meas tran vdout1_1ck1060 FIND v(dout1_1) AT=535.025n

.meas tran vdout1_2ck1060 FIND v(dout1_2) AT=535.025n

.meas tran vdout1_3ck1060 FIND v(dout1_3) AT=535.025n

.meas tran vdout1_4ck1060 FIND v(dout1_4) AT=535.025n

.meas tran vdout1_5ck1060 FIND v(dout1_5) AT=535.025n

.meas tran vdout1_6ck1060 FIND v(dout1_6) AT=535.025n

.meas tran vdout1_7ck1060 FIND v(dout1_7) AT=535.025n

.meas tran vdout1_8ck1060 FIND v(dout1_8) AT=535.025n

.meas tran vdout1_9ck1060 FIND v(dout1_9) AT=535.025n

.meas tran vdout1_10ck1060 FIND v(dout1_10) AT=535.025n

.meas tran vdout1_11ck1060 FIND v(dout1_11) AT=535.025n

.meas tran vdout1_12ck1060 FIND v(dout1_12) AT=535.025n

.meas tran vdout1_13ck1060 FIND v(dout1_13) AT=535.025n

.meas tran vdout1_14ck1060 FIND v(dout1_14) AT=535.025n

.meas tran vdout1_15ck1060 FIND v(dout1_15) AT=535.025n

.meas tran vdout1_0ck1090 FIND v(dout1_0) AT=550.025n

.meas tran vdout1_1ck1090 FIND v(dout1_1) AT=550.025n

.meas tran vdout1_2ck1090 FIND v(dout1_2) AT=550.025n

.meas tran vdout1_3ck1090 FIND v(dout1_3) AT=550.025n

.meas tran vdout1_4ck1090 FIND v(dout1_4) AT=550.025n

.meas tran vdout1_5ck1090 FIND v(dout1_5) AT=550.025n

.meas tran vdout1_6ck1090 FIND v(dout1_6) AT=550.025n

.meas tran vdout1_7ck1090 FIND v(dout1_7) AT=550.025n

.meas tran vdout1_8ck1090 FIND v(dout1_8) AT=550.025n

.meas tran vdout1_9ck1090 FIND v(dout1_9) AT=550.025n

.meas tran vdout1_10ck1090 FIND v(dout1_10) AT=550.025n

.meas tran vdout1_11ck1090 FIND v(dout1_11) AT=550.025n

.meas tran vdout1_12ck1090 FIND v(dout1_12) AT=550.025n

.meas tran vdout1_13ck1090 FIND v(dout1_13) AT=550.025n

.meas tran vdout1_14ck1090 FIND v(dout1_14) AT=550.025n

.meas tran vdout1_15ck1090 FIND v(dout1_15) AT=550.025n

.meas tran vdout1_0ck1100 FIND v(dout1_0) AT=555.025n

.meas tran vdout1_1ck1100 FIND v(dout1_1) AT=555.025n

.meas tran vdout1_2ck1100 FIND v(dout1_2) AT=555.025n

.meas tran vdout1_3ck1100 FIND v(dout1_3) AT=555.025n

.meas tran vdout1_4ck1100 FIND v(dout1_4) AT=555.025n

.meas tran vdout1_5ck1100 FIND v(dout1_5) AT=555.025n

.meas tran vdout1_6ck1100 FIND v(dout1_6) AT=555.025n

.meas tran vdout1_7ck1100 FIND v(dout1_7) AT=555.025n

.meas tran vdout1_8ck1100 FIND v(dout1_8) AT=555.025n

.meas tran vdout1_9ck1100 FIND v(dout1_9) AT=555.025n

.meas tran vdout1_10ck1100 FIND v(dout1_10) AT=555.025n

.meas tran vdout1_11ck1100 FIND v(dout1_11) AT=555.025n

.meas tran vdout1_12ck1100 FIND v(dout1_12) AT=555.025n

.meas tran vdout1_13ck1100 FIND v(dout1_13) AT=555.025n

.meas tran vdout1_14ck1100 FIND v(dout1_14) AT=555.025n

.meas tran vdout1_15ck1100 FIND v(dout1_15) AT=555.025n

.meas tran vdout1_0ck1120 FIND v(dout1_0) AT=565.025n

.meas tran vdout1_1ck1120 FIND v(dout1_1) AT=565.025n

.meas tran vdout1_2ck1120 FIND v(dout1_2) AT=565.025n

.meas tran vdout1_3ck1120 FIND v(dout1_3) AT=565.025n

.meas tran vdout1_4ck1120 FIND v(dout1_4) AT=565.025n

.meas tran vdout1_5ck1120 FIND v(dout1_5) AT=565.025n

.meas tran vdout1_6ck1120 FIND v(dout1_6) AT=565.025n

.meas tran vdout1_7ck1120 FIND v(dout1_7) AT=565.025n

.meas tran vdout1_8ck1120 FIND v(dout1_8) AT=565.025n

.meas tran vdout1_9ck1120 FIND v(dout1_9) AT=565.025n

.meas tran vdout1_10ck1120 FIND v(dout1_10) AT=565.025n

.meas tran vdout1_11ck1120 FIND v(dout1_11) AT=565.025n

.meas tran vdout1_12ck1120 FIND v(dout1_12) AT=565.025n

.meas tran vdout1_13ck1120 FIND v(dout1_13) AT=565.025n

.meas tran vdout1_14ck1120 FIND v(dout1_14) AT=565.025n

.meas tran vdout1_15ck1120 FIND v(dout1_15) AT=565.025n

.meas tran vdout1_0ck1140 FIND v(dout1_0) AT=575.025n

.meas tran vdout1_1ck1140 FIND v(dout1_1) AT=575.025n

.meas tran vdout1_2ck1140 FIND v(dout1_2) AT=575.025n

.meas tran vdout1_3ck1140 FIND v(dout1_3) AT=575.025n

.meas tran vdout1_4ck1140 FIND v(dout1_4) AT=575.025n

.meas tran vdout1_5ck1140 FIND v(dout1_5) AT=575.025n

.meas tran vdout1_6ck1140 FIND v(dout1_6) AT=575.025n

.meas tran vdout1_7ck1140 FIND v(dout1_7) AT=575.025n

.meas tran vdout1_8ck1140 FIND v(dout1_8) AT=575.025n

.meas tran vdout1_9ck1140 FIND v(dout1_9) AT=575.025n

.meas tran vdout1_10ck1140 FIND v(dout1_10) AT=575.025n

.meas tran vdout1_11ck1140 FIND v(dout1_11) AT=575.025n

.meas tran vdout1_12ck1140 FIND v(dout1_12) AT=575.025n

.meas tran vdout1_13ck1140 FIND v(dout1_13) AT=575.025n

.meas tran vdout1_14ck1140 FIND v(dout1_14) AT=575.025n

.meas tran vdout1_15ck1140 FIND v(dout1_15) AT=575.025n

.meas tran vdout1_0ck1170 FIND v(dout1_0) AT=590.025n

.meas tran vdout1_1ck1170 FIND v(dout1_1) AT=590.025n

.meas tran vdout1_2ck1170 FIND v(dout1_2) AT=590.025n

.meas tran vdout1_3ck1170 FIND v(dout1_3) AT=590.025n

.meas tran vdout1_4ck1170 FIND v(dout1_4) AT=590.025n

.meas tran vdout1_5ck1170 FIND v(dout1_5) AT=590.025n

.meas tran vdout1_6ck1170 FIND v(dout1_6) AT=590.025n

.meas tran vdout1_7ck1170 FIND v(dout1_7) AT=590.025n

.meas tran vdout1_8ck1170 FIND v(dout1_8) AT=590.025n

.meas tran vdout1_9ck1170 FIND v(dout1_9) AT=590.025n

.meas tran vdout1_10ck1170 FIND v(dout1_10) AT=590.025n

.meas tran vdout1_11ck1170 FIND v(dout1_11) AT=590.025n

.meas tran vdout1_12ck1170 FIND v(dout1_12) AT=590.025n

.meas tran vdout1_13ck1170 FIND v(dout1_13) AT=590.025n

.meas tran vdout1_14ck1170 FIND v(dout1_14) AT=590.025n

.meas tran vdout1_15ck1170 FIND v(dout1_15) AT=590.025n

.meas tran vdout1_0ck1180 FIND v(dout1_0) AT=595.025n

.meas tran vdout1_1ck1180 FIND v(dout1_1) AT=595.025n

.meas tran vdout1_2ck1180 FIND v(dout1_2) AT=595.025n

.meas tran vdout1_3ck1180 FIND v(dout1_3) AT=595.025n

.meas tran vdout1_4ck1180 FIND v(dout1_4) AT=595.025n

.meas tran vdout1_5ck1180 FIND v(dout1_5) AT=595.025n

.meas tran vdout1_6ck1180 FIND v(dout1_6) AT=595.025n

.meas tran vdout1_7ck1180 FIND v(dout1_7) AT=595.025n

.meas tran vdout1_8ck1180 FIND v(dout1_8) AT=595.025n

.meas tran vdout1_9ck1180 FIND v(dout1_9) AT=595.025n

.meas tran vdout1_10ck1180 FIND v(dout1_10) AT=595.025n

.meas tran vdout1_11ck1180 FIND v(dout1_11) AT=595.025n

.meas tran vdout1_12ck1180 FIND v(dout1_12) AT=595.025n

.meas tran vdout1_13ck1180 FIND v(dout1_13) AT=595.025n

.meas tran vdout1_14ck1180 FIND v(dout1_14) AT=595.025n

.meas tran vdout1_15ck1180 FIND v(dout1_15) AT=595.025n

.meas tran vdout1_0ck1190 FIND v(dout1_0) AT=600.025n

.meas tran vdout1_1ck1190 FIND v(dout1_1) AT=600.025n

.meas tran vdout1_2ck1190 FIND v(dout1_2) AT=600.025n

.meas tran vdout1_3ck1190 FIND v(dout1_3) AT=600.025n

.meas tran vdout1_4ck1190 FIND v(dout1_4) AT=600.025n

.meas tran vdout1_5ck1190 FIND v(dout1_5) AT=600.025n

.meas tran vdout1_6ck1190 FIND v(dout1_6) AT=600.025n

.meas tran vdout1_7ck1190 FIND v(dout1_7) AT=600.025n

.meas tran vdout1_8ck1190 FIND v(dout1_8) AT=600.025n

.meas tran vdout1_9ck1190 FIND v(dout1_9) AT=600.025n

.meas tran vdout1_10ck1190 FIND v(dout1_10) AT=600.025n

.meas tran vdout1_11ck1190 FIND v(dout1_11) AT=600.025n

.meas tran vdout1_12ck1190 FIND v(dout1_12) AT=600.025n

.meas tran vdout1_13ck1190 FIND v(dout1_13) AT=600.025n

.meas tran vdout1_14ck1190 FIND v(dout1_14) AT=600.025n

.meas tran vdout1_15ck1190 FIND v(dout1_15) AT=600.025n

.meas tran vdout1_0ck1210 FIND v(dout1_0) AT=610.025n

.meas tran vdout1_1ck1210 FIND v(dout1_1) AT=610.025n

.meas tran vdout1_2ck1210 FIND v(dout1_2) AT=610.025n

.meas tran vdout1_3ck1210 FIND v(dout1_3) AT=610.025n

.meas tran vdout1_4ck1210 FIND v(dout1_4) AT=610.025n

.meas tran vdout1_5ck1210 FIND v(dout1_5) AT=610.025n

.meas tran vdout1_6ck1210 FIND v(dout1_6) AT=610.025n

.meas tran vdout1_7ck1210 FIND v(dout1_7) AT=610.025n

.meas tran vdout1_8ck1210 FIND v(dout1_8) AT=610.025n

.meas tran vdout1_9ck1210 FIND v(dout1_9) AT=610.025n

.meas tran vdout1_10ck1210 FIND v(dout1_10) AT=610.025n

.meas tran vdout1_11ck1210 FIND v(dout1_11) AT=610.025n

.meas tran vdout1_12ck1210 FIND v(dout1_12) AT=610.025n

.meas tran vdout1_13ck1210 FIND v(dout1_13) AT=610.025n

.meas tran vdout1_14ck1210 FIND v(dout1_14) AT=610.025n

.meas tran vdout1_15ck1210 FIND v(dout1_15) AT=610.025n

.meas tran vdout1_0ck1250 FIND v(dout1_0) AT=630.025n

.meas tran vdout1_1ck1250 FIND v(dout1_1) AT=630.025n

.meas tran vdout1_2ck1250 FIND v(dout1_2) AT=630.025n

.meas tran vdout1_3ck1250 FIND v(dout1_3) AT=630.025n

.meas tran vdout1_4ck1250 FIND v(dout1_4) AT=630.025n

.meas tran vdout1_5ck1250 FIND v(dout1_5) AT=630.025n

.meas tran vdout1_6ck1250 FIND v(dout1_6) AT=630.025n

.meas tran vdout1_7ck1250 FIND v(dout1_7) AT=630.025n

.meas tran vdout1_8ck1250 FIND v(dout1_8) AT=630.025n

.meas tran vdout1_9ck1250 FIND v(dout1_9) AT=630.025n

.meas tran vdout1_10ck1250 FIND v(dout1_10) AT=630.025n

.meas tran vdout1_11ck1250 FIND v(dout1_11) AT=630.025n

.meas tran vdout1_12ck1250 FIND v(dout1_12) AT=630.025n

.meas tran vdout1_13ck1250 FIND v(dout1_13) AT=630.025n

.meas tran vdout1_14ck1250 FIND v(dout1_14) AT=630.025n

.meas tran vdout1_15ck1250 FIND v(dout1_15) AT=630.025n

.meas tran vdout1_0ck1280 FIND v(dout1_0) AT=645.025n

.meas tran vdout1_1ck1280 FIND v(dout1_1) AT=645.025n

.meas tran vdout1_2ck1280 FIND v(dout1_2) AT=645.025n

.meas tran vdout1_3ck1280 FIND v(dout1_3) AT=645.025n

.meas tran vdout1_4ck1280 FIND v(dout1_4) AT=645.025n

.meas tran vdout1_5ck1280 FIND v(dout1_5) AT=645.025n

.meas tran vdout1_6ck1280 FIND v(dout1_6) AT=645.025n

.meas tran vdout1_7ck1280 FIND v(dout1_7) AT=645.025n

.meas tran vdout1_8ck1280 FIND v(dout1_8) AT=645.025n

.meas tran vdout1_9ck1280 FIND v(dout1_9) AT=645.025n

.meas tran vdout1_10ck1280 FIND v(dout1_10) AT=645.025n

.meas tran vdout1_11ck1280 FIND v(dout1_11) AT=645.025n

.meas tran vdout1_12ck1280 FIND v(dout1_12) AT=645.025n

.meas tran vdout1_13ck1280 FIND v(dout1_13) AT=645.025n

.meas tran vdout1_14ck1280 FIND v(dout1_14) AT=645.025n

.meas tran vdout1_15ck1280 FIND v(dout1_15) AT=645.025n

.meas tran vdout1_0ck1290 FIND v(dout1_0) AT=650.025n

.meas tran vdout1_1ck1290 FIND v(dout1_1) AT=650.025n

.meas tran vdout1_2ck1290 FIND v(dout1_2) AT=650.025n

.meas tran vdout1_3ck1290 FIND v(dout1_3) AT=650.025n

.meas tran vdout1_4ck1290 FIND v(dout1_4) AT=650.025n

.meas tran vdout1_5ck1290 FIND v(dout1_5) AT=650.025n

.meas tran vdout1_6ck1290 FIND v(dout1_6) AT=650.025n

.meas tran vdout1_7ck1290 FIND v(dout1_7) AT=650.025n

.meas tran vdout1_8ck1290 FIND v(dout1_8) AT=650.025n

.meas tran vdout1_9ck1290 FIND v(dout1_9) AT=650.025n

.meas tran vdout1_10ck1290 FIND v(dout1_10) AT=650.025n

.meas tran vdout1_11ck1290 FIND v(dout1_11) AT=650.025n

.meas tran vdout1_12ck1290 FIND v(dout1_12) AT=650.025n

.meas tran vdout1_13ck1290 FIND v(dout1_13) AT=650.025n

.meas tran vdout1_14ck1290 FIND v(dout1_14) AT=650.025n

.meas tran vdout1_15ck1290 FIND v(dout1_15) AT=650.025n

.meas tran vdout1_0ck1310 FIND v(dout1_0) AT=660.025n

.meas tran vdout1_1ck1310 FIND v(dout1_1) AT=660.025n

.meas tran vdout1_2ck1310 FIND v(dout1_2) AT=660.025n

.meas tran vdout1_3ck1310 FIND v(dout1_3) AT=660.025n

.meas tran vdout1_4ck1310 FIND v(dout1_4) AT=660.025n

.meas tran vdout1_5ck1310 FIND v(dout1_5) AT=660.025n

.meas tran vdout1_6ck1310 FIND v(dout1_6) AT=660.025n

.meas tran vdout1_7ck1310 FIND v(dout1_7) AT=660.025n

.meas tran vdout1_8ck1310 FIND v(dout1_8) AT=660.025n

.meas tran vdout1_9ck1310 FIND v(dout1_9) AT=660.025n

.meas tran vdout1_10ck1310 FIND v(dout1_10) AT=660.025n

.meas tran vdout1_11ck1310 FIND v(dout1_11) AT=660.025n

.meas tran vdout1_12ck1310 FIND v(dout1_12) AT=660.025n

.meas tran vdout1_13ck1310 FIND v(dout1_13) AT=660.025n

.meas tran vdout1_14ck1310 FIND v(dout1_14) AT=660.025n

.meas tran vdout1_15ck1310 FIND v(dout1_15) AT=660.025n

.meas tran vdout1_0ck1330 FIND v(dout1_0) AT=670.025n

.meas tran vdout1_1ck1330 FIND v(dout1_1) AT=670.025n

.meas tran vdout1_2ck1330 FIND v(dout1_2) AT=670.025n

.meas tran vdout1_3ck1330 FIND v(dout1_3) AT=670.025n

.meas tran vdout1_4ck1330 FIND v(dout1_4) AT=670.025n

.meas tran vdout1_5ck1330 FIND v(dout1_5) AT=670.025n

.meas tran vdout1_6ck1330 FIND v(dout1_6) AT=670.025n

.meas tran vdout1_7ck1330 FIND v(dout1_7) AT=670.025n

.meas tran vdout1_8ck1330 FIND v(dout1_8) AT=670.025n

.meas tran vdout1_9ck1330 FIND v(dout1_9) AT=670.025n

.meas tran vdout1_10ck1330 FIND v(dout1_10) AT=670.025n

.meas tran vdout1_11ck1330 FIND v(dout1_11) AT=670.025n

.meas tran vdout1_12ck1330 FIND v(dout1_12) AT=670.025n

.meas tran vdout1_13ck1330 FIND v(dout1_13) AT=670.025n

.meas tran vdout1_14ck1330 FIND v(dout1_14) AT=670.025n

.meas tran vdout1_15ck1330 FIND v(dout1_15) AT=670.025n

.meas tran vdout1_0ck1340 FIND v(dout1_0) AT=675.025n

.meas tran vdout1_1ck1340 FIND v(dout1_1) AT=675.025n

.meas tran vdout1_2ck1340 FIND v(dout1_2) AT=675.025n

.meas tran vdout1_3ck1340 FIND v(dout1_3) AT=675.025n

.meas tran vdout1_4ck1340 FIND v(dout1_4) AT=675.025n

.meas tran vdout1_5ck1340 FIND v(dout1_5) AT=675.025n

.meas tran vdout1_6ck1340 FIND v(dout1_6) AT=675.025n

.meas tran vdout1_7ck1340 FIND v(dout1_7) AT=675.025n

.meas tran vdout1_8ck1340 FIND v(dout1_8) AT=675.025n

.meas tran vdout1_9ck1340 FIND v(dout1_9) AT=675.025n

.meas tran vdout1_10ck1340 FIND v(dout1_10) AT=675.025n

.meas tran vdout1_11ck1340 FIND v(dout1_11) AT=675.025n

.meas tran vdout1_12ck1340 FIND v(dout1_12) AT=675.025n

.meas tran vdout1_13ck1340 FIND v(dout1_13) AT=675.025n

.meas tran vdout1_14ck1340 FIND v(dout1_14) AT=675.025n

.meas tran vdout1_15ck1340 FIND v(dout1_15) AT=675.025n

.meas tran vdout1_0ck1350 FIND v(dout1_0) AT=680.025n

.meas tran vdout1_1ck1350 FIND v(dout1_1) AT=680.025n

.meas tran vdout1_2ck1350 FIND v(dout1_2) AT=680.025n

.meas tran vdout1_3ck1350 FIND v(dout1_3) AT=680.025n

.meas tran vdout1_4ck1350 FIND v(dout1_4) AT=680.025n

.meas tran vdout1_5ck1350 FIND v(dout1_5) AT=680.025n

.meas tran vdout1_6ck1350 FIND v(dout1_6) AT=680.025n

.meas tran vdout1_7ck1350 FIND v(dout1_7) AT=680.025n

.meas tran vdout1_8ck1350 FIND v(dout1_8) AT=680.025n

.meas tran vdout1_9ck1350 FIND v(dout1_9) AT=680.025n

.meas tran vdout1_10ck1350 FIND v(dout1_10) AT=680.025n

.meas tran vdout1_11ck1350 FIND v(dout1_11) AT=680.025n

.meas tran vdout1_12ck1350 FIND v(dout1_12) AT=680.025n

.meas tran vdout1_13ck1350 FIND v(dout1_13) AT=680.025n

.meas tran vdout1_14ck1350 FIND v(dout1_14) AT=680.025n

.meas tran vdout1_15ck1350 FIND v(dout1_15) AT=680.025n

.meas tran vdout1_0ck1360 FIND v(dout1_0) AT=685.025n

.meas tran vdout1_1ck1360 FIND v(dout1_1) AT=685.025n

.meas tran vdout1_2ck1360 FIND v(dout1_2) AT=685.025n

.meas tran vdout1_3ck1360 FIND v(dout1_3) AT=685.025n

.meas tran vdout1_4ck1360 FIND v(dout1_4) AT=685.025n

.meas tran vdout1_5ck1360 FIND v(dout1_5) AT=685.025n

.meas tran vdout1_6ck1360 FIND v(dout1_6) AT=685.025n

.meas tran vdout1_7ck1360 FIND v(dout1_7) AT=685.025n

.meas tran vdout1_8ck1360 FIND v(dout1_8) AT=685.025n

.meas tran vdout1_9ck1360 FIND v(dout1_9) AT=685.025n

.meas tran vdout1_10ck1360 FIND v(dout1_10) AT=685.025n

.meas tran vdout1_11ck1360 FIND v(dout1_11) AT=685.025n

.meas tran vdout1_12ck1360 FIND v(dout1_12) AT=685.025n

.meas tran vdout1_13ck1360 FIND v(dout1_13) AT=685.025n

.meas tran vdout1_14ck1360 FIND v(dout1_14) AT=685.025n

.meas tran vdout1_15ck1360 FIND v(dout1_15) AT=685.025n

.meas tran vdout1_0ck1370 FIND v(dout1_0) AT=690.025n

.meas tran vdout1_1ck1370 FIND v(dout1_1) AT=690.025n

.meas tran vdout1_2ck1370 FIND v(dout1_2) AT=690.025n

.meas tran vdout1_3ck1370 FIND v(dout1_3) AT=690.025n

.meas tran vdout1_4ck1370 FIND v(dout1_4) AT=690.025n

.meas tran vdout1_5ck1370 FIND v(dout1_5) AT=690.025n

.meas tran vdout1_6ck1370 FIND v(dout1_6) AT=690.025n

.meas tran vdout1_7ck1370 FIND v(dout1_7) AT=690.025n

.meas tran vdout1_8ck1370 FIND v(dout1_8) AT=690.025n

.meas tran vdout1_9ck1370 FIND v(dout1_9) AT=690.025n

.meas tran vdout1_10ck1370 FIND v(dout1_10) AT=690.025n

.meas tran vdout1_11ck1370 FIND v(dout1_11) AT=690.025n

.meas tran vdout1_12ck1370 FIND v(dout1_12) AT=690.025n

.meas tran vdout1_13ck1370 FIND v(dout1_13) AT=690.025n

.meas tran vdout1_14ck1370 FIND v(dout1_14) AT=690.025n

.meas tran vdout1_15ck1370 FIND v(dout1_15) AT=690.025n

.meas tran vdout1_0ck1390 FIND v(dout1_0) AT=700.025n

.meas tran vdout1_1ck1390 FIND v(dout1_1) AT=700.025n

.meas tran vdout1_2ck1390 FIND v(dout1_2) AT=700.025n

.meas tran vdout1_3ck1390 FIND v(dout1_3) AT=700.025n

.meas tran vdout1_4ck1390 FIND v(dout1_4) AT=700.025n

.meas tran vdout1_5ck1390 FIND v(dout1_5) AT=700.025n

.meas tran vdout1_6ck1390 FIND v(dout1_6) AT=700.025n

.meas tran vdout1_7ck1390 FIND v(dout1_7) AT=700.025n

.meas tran vdout1_8ck1390 FIND v(dout1_8) AT=700.025n

.meas tran vdout1_9ck1390 FIND v(dout1_9) AT=700.025n

.meas tran vdout1_10ck1390 FIND v(dout1_10) AT=700.025n

.meas tran vdout1_11ck1390 FIND v(dout1_11) AT=700.025n

.meas tran vdout1_12ck1390 FIND v(dout1_12) AT=700.025n

.meas tran vdout1_13ck1390 FIND v(dout1_13) AT=700.025n

.meas tran vdout1_14ck1390 FIND v(dout1_14) AT=700.025n

.meas tran vdout1_15ck1390 FIND v(dout1_15) AT=700.025n

.meas tran vdout1_0ck1420 FIND v(dout1_0) AT=715.025n

.meas tran vdout1_1ck1420 FIND v(dout1_1) AT=715.025n

.meas tran vdout1_2ck1420 FIND v(dout1_2) AT=715.025n

.meas tran vdout1_3ck1420 FIND v(dout1_3) AT=715.025n

.meas tran vdout1_4ck1420 FIND v(dout1_4) AT=715.025n

.meas tran vdout1_5ck1420 FIND v(dout1_5) AT=715.025n

.meas tran vdout1_6ck1420 FIND v(dout1_6) AT=715.025n

.meas tran vdout1_7ck1420 FIND v(dout1_7) AT=715.025n

.meas tran vdout1_8ck1420 FIND v(dout1_8) AT=715.025n

.meas tran vdout1_9ck1420 FIND v(dout1_9) AT=715.025n

.meas tran vdout1_10ck1420 FIND v(dout1_10) AT=715.025n

.meas tran vdout1_11ck1420 FIND v(dout1_11) AT=715.025n

.meas tran vdout1_12ck1420 FIND v(dout1_12) AT=715.025n

.meas tran vdout1_13ck1420 FIND v(dout1_13) AT=715.025n

.meas tran vdout1_14ck1420 FIND v(dout1_14) AT=715.025n

.meas tran vdout1_15ck1420 FIND v(dout1_15) AT=715.025n

.meas tran vdout1_0ck1480 FIND v(dout1_0) AT=745.025n

.meas tran vdout1_1ck1480 FIND v(dout1_1) AT=745.025n

.meas tran vdout1_2ck1480 FIND v(dout1_2) AT=745.025n

.meas tran vdout1_3ck1480 FIND v(dout1_3) AT=745.025n

.meas tran vdout1_4ck1480 FIND v(dout1_4) AT=745.025n

.meas tran vdout1_5ck1480 FIND v(dout1_5) AT=745.025n

.meas tran vdout1_6ck1480 FIND v(dout1_6) AT=745.025n

.meas tran vdout1_7ck1480 FIND v(dout1_7) AT=745.025n

.meas tran vdout1_8ck1480 FIND v(dout1_8) AT=745.025n

.meas tran vdout1_9ck1480 FIND v(dout1_9) AT=745.025n

.meas tran vdout1_10ck1480 FIND v(dout1_10) AT=745.025n

.meas tran vdout1_11ck1480 FIND v(dout1_11) AT=745.025n

.meas tran vdout1_12ck1480 FIND v(dout1_12) AT=745.025n

.meas tran vdout1_13ck1480 FIND v(dout1_13) AT=745.025n

.meas tran vdout1_14ck1480 FIND v(dout1_14) AT=745.025n

.meas tran vdout1_15ck1480 FIND v(dout1_15) AT=745.025n

.meas tran vdout1_0ck1500 FIND v(dout1_0) AT=755.025n

.meas tran vdout1_1ck1500 FIND v(dout1_1) AT=755.025n

.meas tran vdout1_2ck1500 FIND v(dout1_2) AT=755.025n

.meas tran vdout1_3ck1500 FIND v(dout1_3) AT=755.025n

.meas tran vdout1_4ck1500 FIND v(dout1_4) AT=755.025n

.meas tran vdout1_5ck1500 FIND v(dout1_5) AT=755.025n

.meas tran vdout1_6ck1500 FIND v(dout1_6) AT=755.025n

.meas tran vdout1_7ck1500 FIND v(dout1_7) AT=755.025n

.meas tran vdout1_8ck1500 FIND v(dout1_8) AT=755.025n

.meas tran vdout1_9ck1500 FIND v(dout1_9) AT=755.025n

.meas tran vdout1_10ck1500 FIND v(dout1_10) AT=755.025n

.meas tran vdout1_11ck1500 FIND v(dout1_11) AT=755.025n

.meas tran vdout1_12ck1500 FIND v(dout1_12) AT=755.025n

.meas tran vdout1_13ck1500 FIND v(dout1_13) AT=755.025n

.meas tran vdout1_14ck1500 FIND v(dout1_14) AT=755.025n

.meas tran vdout1_15ck1500 FIND v(dout1_15) AT=755.025n

.meas tran vdout1_0ck1520 FIND v(dout1_0) AT=765.025n

.meas tran vdout1_1ck1520 FIND v(dout1_1) AT=765.025n

.meas tran vdout1_2ck1520 FIND v(dout1_2) AT=765.025n

.meas tran vdout1_3ck1520 FIND v(dout1_3) AT=765.025n

.meas tran vdout1_4ck1520 FIND v(dout1_4) AT=765.025n

.meas tran vdout1_5ck1520 FIND v(dout1_5) AT=765.025n

.meas tran vdout1_6ck1520 FIND v(dout1_6) AT=765.025n

.meas tran vdout1_7ck1520 FIND v(dout1_7) AT=765.025n

.meas tran vdout1_8ck1520 FIND v(dout1_8) AT=765.025n

.meas tran vdout1_9ck1520 FIND v(dout1_9) AT=765.025n

.meas tran vdout1_10ck1520 FIND v(dout1_10) AT=765.025n

.meas tran vdout1_11ck1520 FIND v(dout1_11) AT=765.025n

.meas tran vdout1_12ck1520 FIND v(dout1_12) AT=765.025n

.meas tran vdout1_13ck1520 FIND v(dout1_13) AT=765.025n

.meas tran vdout1_14ck1520 FIND v(dout1_14) AT=765.025n

.meas tran vdout1_15ck1520 FIND v(dout1_15) AT=765.025n

.meas tran vdout1_0ck1540 FIND v(dout1_0) AT=775.025n

.meas tran vdout1_1ck1540 FIND v(dout1_1) AT=775.025n

.meas tran vdout1_2ck1540 FIND v(dout1_2) AT=775.025n

.meas tran vdout1_3ck1540 FIND v(dout1_3) AT=775.025n

.meas tran vdout1_4ck1540 FIND v(dout1_4) AT=775.025n

.meas tran vdout1_5ck1540 FIND v(dout1_5) AT=775.025n

.meas tran vdout1_6ck1540 FIND v(dout1_6) AT=775.025n

.meas tran vdout1_7ck1540 FIND v(dout1_7) AT=775.025n

.meas tran vdout1_8ck1540 FIND v(dout1_8) AT=775.025n

.meas tran vdout1_9ck1540 FIND v(dout1_9) AT=775.025n

.meas tran vdout1_10ck1540 FIND v(dout1_10) AT=775.025n

.meas tran vdout1_11ck1540 FIND v(dout1_11) AT=775.025n

.meas tran vdout1_12ck1540 FIND v(dout1_12) AT=775.025n

.meas tran vdout1_13ck1540 FIND v(dout1_13) AT=775.025n

.meas tran vdout1_14ck1540 FIND v(dout1_14) AT=775.025n

.meas tran vdout1_15ck1540 FIND v(dout1_15) AT=775.025n

.meas tran vdout1_0ck1560 FIND v(dout1_0) AT=785.025n

.meas tran vdout1_1ck1560 FIND v(dout1_1) AT=785.025n

.meas tran vdout1_2ck1560 FIND v(dout1_2) AT=785.025n

.meas tran vdout1_3ck1560 FIND v(dout1_3) AT=785.025n

.meas tran vdout1_4ck1560 FIND v(dout1_4) AT=785.025n

.meas tran vdout1_5ck1560 FIND v(dout1_5) AT=785.025n

.meas tran vdout1_6ck1560 FIND v(dout1_6) AT=785.025n

.meas tran vdout1_7ck1560 FIND v(dout1_7) AT=785.025n

.meas tran vdout1_8ck1560 FIND v(dout1_8) AT=785.025n

.meas tran vdout1_9ck1560 FIND v(dout1_9) AT=785.025n

.meas tran vdout1_10ck1560 FIND v(dout1_10) AT=785.025n

.meas tran vdout1_11ck1560 FIND v(dout1_11) AT=785.025n

.meas tran vdout1_12ck1560 FIND v(dout1_12) AT=785.025n

.meas tran vdout1_13ck1560 FIND v(dout1_13) AT=785.025n

.meas tran vdout1_14ck1560 FIND v(dout1_14) AT=785.025n

.meas tran vdout1_15ck1560 FIND v(dout1_15) AT=785.025n

.meas tran vdout1_0ck1580 FIND v(dout1_0) AT=795.025n

.meas tran vdout1_1ck1580 FIND v(dout1_1) AT=795.025n

.meas tran vdout1_2ck1580 FIND v(dout1_2) AT=795.025n

.meas tran vdout1_3ck1580 FIND v(dout1_3) AT=795.025n

.meas tran vdout1_4ck1580 FIND v(dout1_4) AT=795.025n

.meas tran vdout1_5ck1580 FIND v(dout1_5) AT=795.025n

.meas tran vdout1_6ck1580 FIND v(dout1_6) AT=795.025n

.meas tran vdout1_7ck1580 FIND v(dout1_7) AT=795.025n

.meas tran vdout1_8ck1580 FIND v(dout1_8) AT=795.025n

.meas tran vdout1_9ck1580 FIND v(dout1_9) AT=795.025n

.meas tran vdout1_10ck1580 FIND v(dout1_10) AT=795.025n

.meas tran vdout1_11ck1580 FIND v(dout1_11) AT=795.025n

.meas tran vdout1_12ck1580 FIND v(dout1_12) AT=795.025n

.meas tran vdout1_13ck1580 FIND v(dout1_13) AT=795.025n

.meas tran vdout1_14ck1580 FIND v(dout1_14) AT=795.025n

.meas tran vdout1_15ck1580 FIND v(dout1_15) AT=795.025n

.meas tran vdout1_0ck1610 FIND v(dout1_0) AT=810.025n

.meas tran vdout1_1ck1610 FIND v(dout1_1) AT=810.025n

.meas tran vdout1_2ck1610 FIND v(dout1_2) AT=810.025n

.meas tran vdout1_3ck1610 FIND v(dout1_3) AT=810.025n

.meas tran vdout1_4ck1610 FIND v(dout1_4) AT=810.025n

.meas tran vdout1_5ck1610 FIND v(dout1_5) AT=810.025n

.meas tran vdout1_6ck1610 FIND v(dout1_6) AT=810.025n

.meas tran vdout1_7ck1610 FIND v(dout1_7) AT=810.025n

.meas tran vdout1_8ck1610 FIND v(dout1_8) AT=810.025n

.meas tran vdout1_9ck1610 FIND v(dout1_9) AT=810.025n

.meas tran vdout1_10ck1610 FIND v(dout1_10) AT=810.025n

.meas tran vdout1_11ck1610 FIND v(dout1_11) AT=810.025n

.meas tran vdout1_12ck1610 FIND v(dout1_12) AT=810.025n

.meas tran vdout1_13ck1610 FIND v(dout1_13) AT=810.025n

.meas tran vdout1_14ck1610 FIND v(dout1_14) AT=810.025n

.meas tran vdout1_15ck1610 FIND v(dout1_15) AT=810.025n

.meas tran vdout1_0ck1620 FIND v(dout1_0) AT=815.025n

.meas tran vdout1_1ck1620 FIND v(dout1_1) AT=815.025n

.meas tran vdout1_2ck1620 FIND v(dout1_2) AT=815.025n

.meas tran vdout1_3ck1620 FIND v(dout1_3) AT=815.025n

.meas tran vdout1_4ck1620 FIND v(dout1_4) AT=815.025n

.meas tran vdout1_5ck1620 FIND v(dout1_5) AT=815.025n

.meas tran vdout1_6ck1620 FIND v(dout1_6) AT=815.025n

.meas tran vdout1_7ck1620 FIND v(dout1_7) AT=815.025n

.meas tran vdout1_8ck1620 FIND v(dout1_8) AT=815.025n

.meas tran vdout1_9ck1620 FIND v(dout1_9) AT=815.025n

.meas tran vdout1_10ck1620 FIND v(dout1_10) AT=815.025n

.meas tran vdout1_11ck1620 FIND v(dout1_11) AT=815.025n

.meas tran vdout1_12ck1620 FIND v(dout1_12) AT=815.025n

.meas tran vdout1_13ck1620 FIND v(dout1_13) AT=815.025n

.meas tran vdout1_14ck1620 FIND v(dout1_14) AT=815.025n

.meas tran vdout1_15ck1620 FIND v(dout1_15) AT=815.025n

.meas tran vdout1_0ck1640 FIND v(dout1_0) AT=825.025n

.meas tran vdout1_1ck1640 FIND v(dout1_1) AT=825.025n

.meas tran vdout1_2ck1640 FIND v(dout1_2) AT=825.025n

.meas tran vdout1_3ck1640 FIND v(dout1_3) AT=825.025n

.meas tran vdout1_4ck1640 FIND v(dout1_4) AT=825.025n

.meas tran vdout1_5ck1640 FIND v(dout1_5) AT=825.025n

.meas tran vdout1_6ck1640 FIND v(dout1_6) AT=825.025n

.meas tran vdout1_7ck1640 FIND v(dout1_7) AT=825.025n

.meas tran vdout1_8ck1640 FIND v(dout1_8) AT=825.025n

.meas tran vdout1_9ck1640 FIND v(dout1_9) AT=825.025n

.meas tran vdout1_10ck1640 FIND v(dout1_10) AT=825.025n

.meas tran vdout1_11ck1640 FIND v(dout1_11) AT=825.025n

.meas tran vdout1_12ck1640 FIND v(dout1_12) AT=825.025n

.meas tran vdout1_13ck1640 FIND v(dout1_13) AT=825.025n

.meas tran vdout1_14ck1640 FIND v(dout1_14) AT=825.025n

.meas tran vdout1_15ck1640 FIND v(dout1_15) AT=825.025n

.meas tran vdout1_0ck1650 FIND v(dout1_0) AT=830.025n

.meas tran vdout1_1ck1650 FIND v(dout1_1) AT=830.025n

.meas tran vdout1_2ck1650 FIND v(dout1_2) AT=830.025n

.meas tran vdout1_3ck1650 FIND v(dout1_3) AT=830.025n

.meas tran vdout1_4ck1650 FIND v(dout1_4) AT=830.025n

.meas tran vdout1_5ck1650 FIND v(dout1_5) AT=830.025n

.meas tran vdout1_6ck1650 FIND v(dout1_6) AT=830.025n

.meas tran vdout1_7ck1650 FIND v(dout1_7) AT=830.025n

.meas tran vdout1_8ck1650 FIND v(dout1_8) AT=830.025n

.meas tran vdout1_9ck1650 FIND v(dout1_9) AT=830.025n

.meas tran vdout1_10ck1650 FIND v(dout1_10) AT=830.025n

.meas tran vdout1_11ck1650 FIND v(dout1_11) AT=830.025n

.meas tran vdout1_12ck1650 FIND v(dout1_12) AT=830.025n

.meas tran vdout1_13ck1650 FIND v(dout1_13) AT=830.025n

.meas tran vdout1_14ck1650 FIND v(dout1_14) AT=830.025n

.meas tran vdout1_15ck1650 FIND v(dout1_15) AT=830.025n

.meas tran vdout1_0ck1660 FIND v(dout1_0) AT=835.025n

.meas tran vdout1_1ck1660 FIND v(dout1_1) AT=835.025n

.meas tran vdout1_2ck1660 FIND v(dout1_2) AT=835.025n

.meas tran vdout1_3ck1660 FIND v(dout1_3) AT=835.025n

.meas tran vdout1_4ck1660 FIND v(dout1_4) AT=835.025n

.meas tran vdout1_5ck1660 FIND v(dout1_5) AT=835.025n

.meas tran vdout1_6ck1660 FIND v(dout1_6) AT=835.025n

.meas tran vdout1_7ck1660 FIND v(dout1_7) AT=835.025n

.meas tran vdout1_8ck1660 FIND v(dout1_8) AT=835.025n

.meas tran vdout1_9ck1660 FIND v(dout1_9) AT=835.025n

.meas tran vdout1_10ck1660 FIND v(dout1_10) AT=835.025n

.meas tran vdout1_11ck1660 FIND v(dout1_11) AT=835.025n

.meas tran vdout1_12ck1660 FIND v(dout1_12) AT=835.025n

.meas tran vdout1_13ck1660 FIND v(dout1_13) AT=835.025n

.meas tran vdout1_14ck1660 FIND v(dout1_14) AT=835.025n

.meas tran vdout1_15ck1660 FIND v(dout1_15) AT=835.025n

.meas tran vdout1_0ck1670 FIND v(dout1_0) AT=840.025n

.meas tran vdout1_1ck1670 FIND v(dout1_1) AT=840.025n

.meas tran vdout1_2ck1670 FIND v(dout1_2) AT=840.025n

.meas tran vdout1_3ck1670 FIND v(dout1_3) AT=840.025n

.meas tran vdout1_4ck1670 FIND v(dout1_4) AT=840.025n

.meas tran vdout1_5ck1670 FIND v(dout1_5) AT=840.025n

.meas tran vdout1_6ck1670 FIND v(dout1_6) AT=840.025n

.meas tran vdout1_7ck1670 FIND v(dout1_7) AT=840.025n

.meas tran vdout1_8ck1670 FIND v(dout1_8) AT=840.025n

.meas tran vdout1_9ck1670 FIND v(dout1_9) AT=840.025n

.meas tran vdout1_10ck1670 FIND v(dout1_10) AT=840.025n

.meas tran vdout1_11ck1670 FIND v(dout1_11) AT=840.025n

.meas tran vdout1_12ck1670 FIND v(dout1_12) AT=840.025n

.meas tran vdout1_13ck1670 FIND v(dout1_13) AT=840.025n

.meas tran vdout1_14ck1670 FIND v(dout1_14) AT=840.025n

.meas tran vdout1_15ck1670 FIND v(dout1_15) AT=840.025n

.meas tran vdout1_0ck1690 FIND v(dout1_0) AT=850.025n

.meas tran vdout1_1ck1690 FIND v(dout1_1) AT=850.025n

.meas tran vdout1_2ck1690 FIND v(dout1_2) AT=850.025n

.meas tran vdout1_3ck1690 FIND v(dout1_3) AT=850.025n

.meas tran vdout1_4ck1690 FIND v(dout1_4) AT=850.025n

.meas tran vdout1_5ck1690 FIND v(dout1_5) AT=850.025n

.meas tran vdout1_6ck1690 FIND v(dout1_6) AT=850.025n

.meas tran vdout1_7ck1690 FIND v(dout1_7) AT=850.025n

.meas tran vdout1_8ck1690 FIND v(dout1_8) AT=850.025n

.meas tran vdout1_9ck1690 FIND v(dout1_9) AT=850.025n

.meas tran vdout1_10ck1690 FIND v(dout1_10) AT=850.025n

.meas tran vdout1_11ck1690 FIND v(dout1_11) AT=850.025n

.meas tran vdout1_12ck1690 FIND v(dout1_12) AT=850.025n

.meas tran vdout1_13ck1690 FIND v(dout1_13) AT=850.025n

.meas tran vdout1_14ck1690 FIND v(dout1_14) AT=850.025n

.meas tran vdout1_15ck1690 FIND v(dout1_15) AT=850.025n

.meas tran vdout1_0ck1700 FIND v(dout1_0) AT=855.025n

.meas tran vdout1_1ck1700 FIND v(dout1_1) AT=855.025n

.meas tran vdout1_2ck1700 FIND v(dout1_2) AT=855.025n

.meas tran vdout1_3ck1700 FIND v(dout1_3) AT=855.025n

.meas tran vdout1_4ck1700 FIND v(dout1_4) AT=855.025n

.meas tran vdout1_5ck1700 FIND v(dout1_5) AT=855.025n

.meas tran vdout1_6ck1700 FIND v(dout1_6) AT=855.025n

.meas tran vdout1_7ck1700 FIND v(dout1_7) AT=855.025n

.meas tran vdout1_8ck1700 FIND v(dout1_8) AT=855.025n

.meas tran vdout1_9ck1700 FIND v(dout1_9) AT=855.025n

.meas tran vdout1_10ck1700 FIND v(dout1_10) AT=855.025n

.meas tran vdout1_11ck1700 FIND v(dout1_11) AT=855.025n

.meas tran vdout1_12ck1700 FIND v(dout1_12) AT=855.025n

.meas tran vdout1_13ck1700 FIND v(dout1_13) AT=855.025n

.meas tran vdout1_14ck1700 FIND v(dout1_14) AT=855.025n

.meas tran vdout1_15ck1700 FIND v(dout1_15) AT=855.025n

.meas tran vdout1_0ck1720 FIND v(dout1_0) AT=865.025n

.meas tran vdout1_1ck1720 FIND v(dout1_1) AT=865.025n

.meas tran vdout1_2ck1720 FIND v(dout1_2) AT=865.025n

.meas tran vdout1_3ck1720 FIND v(dout1_3) AT=865.025n

.meas tran vdout1_4ck1720 FIND v(dout1_4) AT=865.025n

.meas tran vdout1_5ck1720 FIND v(dout1_5) AT=865.025n

.meas tran vdout1_6ck1720 FIND v(dout1_6) AT=865.025n

.meas tran vdout1_7ck1720 FIND v(dout1_7) AT=865.025n

.meas tran vdout1_8ck1720 FIND v(dout1_8) AT=865.025n

.meas tran vdout1_9ck1720 FIND v(dout1_9) AT=865.025n

.meas tran vdout1_10ck1720 FIND v(dout1_10) AT=865.025n

.meas tran vdout1_11ck1720 FIND v(dout1_11) AT=865.025n

.meas tran vdout1_12ck1720 FIND v(dout1_12) AT=865.025n

.meas tran vdout1_13ck1720 FIND v(dout1_13) AT=865.025n

.meas tran vdout1_14ck1720 FIND v(dout1_14) AT=865.025n

.meas tran vdout1_15ck1720 FIND v(dout1_15) AT=865.025n

.meas tran vdout1_0ck1730 FIND v(dout1_0) AT=870.025n

.meas tran vdout1_1ck1730 FIND v(dout1_1) AT=870.025n

.meas tran vdout1_2ck1730 FIND v(dout1_2) AT=870.025n

.meas tran vdout1_3ck1730 FIND v(dout1_3) AT=870.025n

.meas tran vdout1_4ck1730 FIND v(dout1_4) AT=870.025n

.meas tran vdout1_5ck1730 FIND v(dout1_5) AT=870.025n

.meas tran vdout1_6ck1730 FIND v(dout1_6) AT=870.025n

.meas tran vdout1_7ck1730 FIND v(dout1_7) AT=870.025n

.meas tran vdout1_8ck1730 FIND v(dout1_8) AT=870.025n

.meas tran vdout1_9ck1730 FIND v(dout1_9) AT=870.025n

.meas tran vdout1_10ck1730 FIND v(dout1_10) AT=870.025n

.meas tran vdout1_11ck1730 FIND v(dout1_11) AT=870.025n

.meas tran vdout1_12ck1730 FIND v(dout1_12) AT=870.025n

.meas tran vdout1_13ck1730 FIND v(dout1_13) AT=870.025n

.meas tran vdout1_14ck1730 FIND v(dout1_14) AT=870.025n

.meas tran vdout1_15ck1730 FIND v(dout1_15) AT=870.025n

.meas tran vdout1_0ck1750 FIND v(dout1_0) AT=880.025n

.meas tran vdout1_1ck1750 FIND v(dout1_1) AT=880.025n

.meas tran vdout1_2ck1750 FIND v(dout1_2) AT=880.025n

.meas tran vdout1_3ck1750 FIND v(dout1_3) AT=880.025n

.meas tran vdout1_4ck1750 FIND v(dout1_4) AT=880.025n

.meas tran vdout1_5ck1750 FIND v(dout1_5) AT=880.025n

.meas tran vdout1_6ck1750 FIND v(dout1_6) AT=880.025n

.meas tran vdout1_7ck1750 FIND v(dout1_7) AT=880.025n

.meas tran vdout1_8ck1750 FIND v(dout1_8) AT=880.025n

.meas tran vdout1_9ck1750 FIND v(dout1_9) AT=880.025n

.meas tran vdout1_10ck1750 FIND v(dout1_10) AT=880.025n

.meas tran vdout1_11ck1750 FIND v(dout1_11) AT=880.025n

.meas tran vdout1_12ck1750 FIND v(dout1_12) AT=880.025n

.meas tran vdout1_13ck1750 FIND v(dout1_13) AT=880.025n

.meas tran vdout1_14ck1750 FIND v(dout1_14) AT=880.025n

.meas tran vdout1_15ck1750 FIND v(dout1_15) AT=880.025n

.meas tran vdout1_0ck1760 FIND v(dout1_0) AT=885.025n

.meas tran vdout1_1ck1760 FIND v(dout1_1) AT=885.025n

.meas tran vdout1_2ck1760 FIND v(dout1_2) AT=885.025n

.meas tran vdout1_3ck1760 FIND v(dout1_3) AT=885.025n

.meas tran vdout1_4ck1760 FIND v(dout1_4) AT=885.025n

.meas tran vdout1_5ck1760 FIND v(dout1_5) AT=885.025n

.meas tran vdout1_6ck1760 FIND v(dout1_6) AT=885.025n

.meas tran vdout1_7ck1760 FIND v(dout1_7) AT=885.025n

.meas tran vdout1_8ck1760 FIND v(dout1_8) AT=885.025n

.meas tran vdout1_9ck1760 FIND v(dout1_9) AT=885.025n

.meas tran vdout1_10ck1760 FIND v(dout1_10) AT=885.025n

.meas tran vdout1_11ck1760 FIND v(dout1_11) AT=885.025n

.meas tran vdout1_12ck1760 FIND v(dout1_12) AT=885.025n

.meas tran vdout1_13ck1760 FIND v(dout1_13) AT=885.025n

.meas tran vdout1_14ck1760 FIND v(dout1_14) AT=885.025n

.meas tran vdout1_15ck1760 FIND v(dout1_15) AT=885.025n

.meas tran vdout1_0ck1820 FIND v(dout1_0) AT=915.025n

.meas tran vdout1_1ck1820 FIND v(dout1_1) AT=915.025n

.meas tran vdout1_2ck1820 FIND v(dout1_2) AT=915.025n

.meas tran vdout1_3ck1820 FIND v(dout1_3) AT=915.025n

.meas tran vdout1_4ck1820 FIND v(dout1_4) AT=915.025n

.meas tran vdout1_5ck1820 FIND v(dout1_5) AT=915.025n

.meas tran vdout1_6ck1820 FIND v(dout1_6) AT=915.025n

.meas tran vdout1_7ck1820 FIND v(dout1_7) AT=915.025n

.meas tran vdout1_8ck1820 FIND v(dout1_8) AT=915.025n

.meas tran vdout1_9ck1820 FIND v(dout1_9) AT=915.025n

.meas tran vdout1_10ck1820 FIND v(dout1_10) AT=915.025n

.meas tran vdout1_11ck1820 FIND v(dout1_11) AT=915.025n

.meas tran vdout1_12ck1820 FIND v(dout1_12) AT=915.025n

.meas tran vdout1_13ck1820 FIND v(dout1_13) AT=915.025n

.meas tran vdout1_14ck1820 FIND v(dout1_14) AT=915.025n

.meas tran vdout1_15ck1820 FIND v(dout1_15) AT=915.025n

.meas tran vdout1_0ck1830 FIND v(dout1_0) AT=920.025n

.meas tran vdout1_1ck1830 FIND v(dout1_1) AT=920.025n

.meas tran vdout1_2ck1830 FIND v(dout1_2) AT=920.025n

.meas tran vdout1_3ck1830 FIND v(dout1_3) AT=920.025n

.meas tran vdout1_4ck1830 FIND v(dout1_4) AT=920.025n

.meas tran vdout1_5ck1830 FIND v(dout1_5) AT=920.025n

.meas tran vdout1_6ck1830 FIND v(dout1_6) AT=920.025n

.meas tran vdout1_7ck1830 FIND v(dout1_7) AT=920.025n

.meas tran vdout1_8ck1830 FIND v(dout1_8) AT=920.025n

.meas tran vdout1_9ck1830 FIND v(dout1_9) AT=920.025n

.meas tran vdout1_10ck1830 FIND v(dout1_10) AT=920.025n

.meas tran vdout1_11ck1830 FIND v(dout1_11) AT=920.025n

.meas tran vdout1_12ck1830 FIND v(dout1_12) AT=920.025n

.meas tran vdout1_13ck1830 FIND v(dout1_13) AT=920.025n

.meas tran vdout1_14ck1830 FIND v(dout1_14) AT=920.025n

.meas tran vdout1_15ck1830 FIND v(dout1_15) AT=920.025n

.meas tran vdout1_0ck1840 FIND v(dout1_0) AT=925.025n

.meas tran vdout1_1ck1840 FIND v(dout1_1) AT=925.025n

.meas tran vdout1_2ck1840 FIND v(dout1_2) AT=925.025n

.meas tran vdout1_3ck1840 FIND v(dout1_3) AT=925.025n

.meas tran vdout1_4ck1840 FIND v(dout1_4) AT=925.025n

.meas tran vdout1_5ck1840 FIND v(dout1_5) AT=925.025n

.meas tran vdout1_6ck1840 FIND v(dout1_6) AT=925.025n

.meas tran vdout1_7ck1840 FIND v(dout1_7) AT=925.025n

.meas tran vdout1_8ck1840 FIND v(dout1_8) AT=925.025n

.meas tran vdout1_9ck1840 FIND v(dout1_9) AT=925.025n

.meas tran vdout1_10ck1840 FIND v(dout1_10) AT=925.025n

.meas tran vdout1_11ck1840 FIND v(dout1_11) AT=925.025n

.meas tran vdout1_12ck1840 FIND v(dout1_12) AT=925.025n

.meas tran vdout1_13ck1840 FIND v(dout1_13) AT=925.025n

.meas tran vdout1_14ck1840 FIND v(dout1_14) AT=925.025n

.meas tran vdout1_15ck1840 FIND v(dout1_15) AT=925.025n

.meas tran vdout1_0ck1860 FIND v(dout1_0) AT=935.025n

.meas tran vdout1_1ck1860 FIND v(dout1_1) AT=935.025n

.meas tran vdout1_2ck1860 FIND v(dout1_2) AT=935.025n

.meas tran vdout1_3ck1860 FIND v(dout1_3) AT=935.025n

.meas tran vdout1_4ck1860 FIND v(dout1_4) AT=935.025n

.meas tran vdout1_5ck1860 FIND v(dout1_5) AT=935.025n

.meas tran vdout1_6ck1860 FIND v(dout1_6) AT=935.025n

.meas tran vdout1_7ck1860 FIND v(dout1_7) AT=935.025n

.meas tran vdout1_8ck1860 FIND v(dout1_8) AT=935.025n

.meas tran vdout1_9ck1860 FIND v(dout1_9) AT=935.025n

.meas tran vdout1_10ck1860 FIND v(dout1_10) AT=935.025n

.meas tran vdout1_11ck1860 FIND v(dout1_11) AT=935.025n

.meas tran vdout1_12ck1860 FIND v(dout1_12) AT=935.025n

.meas tran vdout1_13ck1860 FIND v(dout1_13) AT=935.025n

.meas tran vdout1_14ck1860 FIND v(dout1_14) AT=935.025n

.meas tran vdout1_15ck1860 FIND v(dout1_15) AT=935.025n

.meas tran vdout1_0ck1870 FIND v(dout1_0) AT=940.025n

.meas tran vdout1_1ck1870 FIND v(dout1_1) AT=940.025n

.meas tran vdout1_2ck1870 FIND v(dout1_2) AT=940.025n

.meas tran vdout1_3ck1870 FIND v(dout1_3) AT=940.025n

.meas tran vdout1_4ck1870 FIND v(dout1_4) AT=940.025n

.meas tran vdout1_5ck1870 FIND v(dout1_5) AT=940.025n

.meas tran vdout1_6ck1870 FIND v(dout1_6) AT=940.025n

.meas tran vdout1_7ck1870 FIND v(dout1_7) AT=940.025n

.meas tran vdout1_8ck1870 FIND v(dout1_8) AT=940.025n

.meas tran vdout1_9ck1870 FIND v(dout1_9) AT=940.025n

.meas tran vdout1_10ck1870 FIND v(dout1_10) AT=940.025n

.meas tran vdout1_11ck1870 FIND v(dout1_11) AT=940.025n

.meas tran vdout1_12ck1870 FIND v(dout1_12) AT=940.025n

.meas tran vdout1_13ck1870 FIND v(dout1_13) AT=940.025n

.meas tran vdout1_14ck1870 FIND v(dout1_14) AT=940.025n

.meas tran vdout1_15ck1870 FIND v(dout1_15) AT=940.025n

.meas tran vdout1_0ck1930 FIND v(dout1_0) AT=970.025n

.meas tran vdout1_1ck1930 FIND v(dout1_1) AT=970.025n

.meas tran vdout1_2ck1930 FIND v(dout1_2) AT=970.025n

.meas tran vdout1_3ck1930 FIND v(dout1_3) AT=970.025n

.meas tran vdout1_4ck1930 FIND v(dout1_4) AT=970.025n

.meas tran vdout1_5ck1930 FIND v(dout1_5) AT=970.025n

.meas tran vdout1_6ck1930 FIND v(dout1_6) AT=970.025n

.meas tran vdout1_7ck1930 FIND v(dout1_7) AT=970.025n

.meas tran vdout1_8ck1930 FIND v(dout1_8) AT=970.025n

.meas tran vdout1_9ck1930 FIND v(dout1_9) AT=970.025n

.meas tran vdout1_10ck1930 FIND v(dout1_10) AT=970.025n

.meas tran vdout1_11ck1930 FIND v(dout1_11) AT=970.025n

.meas tran vdout1_12ck1930 FIND v(dout1_12) AT=970.025n

.meas tran vdout1_13ck1930 FIND v(dout1_13) AT=970.025n

.meas tran vdout1_14ck1930 FIND v(dout1_14) AT=970.025n

.meas tran vdout1_15ck1930 FIND v(dout1_15) AT=970.025n

.meas tran vdout1_0ck1940 FIND v(dout1_0) AT=975.025n

.meas tran vdout1_1ck1940 FIND v(dout1_1) AT=975.025n

.meas tran vdout1_2ck1940 FIND v(dout1_2) AT=975.025n

.meas tran vdout1_3ck1940 FIND v(dout1_3) AT=975.025n

.meas tran vdout1_4ck1940 FIND v(dout1_4) AT=975.025n

.meas tran vdout1_5ck1940 FIND v(dout1_5) AT=975.025n

.meas tran vdout1_6ck1940 FIND v(dout1_6) AT=975.025n

.meas tran vdout1_7ck1940 FIND v(dout1_7) AT=975.025n

.meas tran vdout1_8ck1940 FIND v(dout1_8) AT=975.025n

.meas tran vdout1_9ck1940 FIND v(dout1_9) AT=975.025n

.meas tran vdout1_10ck1940 FIND v(dout1_10) AT=975.025n

.meas tran vdout1_11ck1940 FIND v(dout1_11) AT=975.025n

.meas tran vdout1_12ck1940 FIND v(dout1_12) AT=975.025n

.meas tran vdout1_13ck1940 FIND v(dout1_13) AT=975.025n

.meas tran vdout1_14ck1940 FIND v(dout1_14) AT=975.025n

.meas tran vdout1_15ck1940 FIND v(dout1_15) AT=975.025n

.meas tran vdout1_0ck1950 FIND v(dout1_0) AT=980.025n

.meas tran vdout1_1ck1950 FIND v(dout1_1) AT=980.025n

.meas tran vdout1_2ck1950 FIND v(dout1_2) AT=980.025n

.meas tran vdout1_3ck1950 FIND v(dout1_3) AT=980.025n

.meas tran vdout1_4ck1950 FIND v(dout1_4) AT=980.025n

.meas tran vdout1_5ck1950 FIND v(dout1_5) AT=980.025n

.meas tran vdout1_6ck1950 FIND v(dout1_6) AT=980.025n

.meas tran vdout1_7ck1950 FIND v(dout1_7) AT=980.025n

.meas tran vdout1_8ck1950 FIND v(dout1_8) AT=980.025n

.meas tran vdout1_9ck1950 FIND v(dout1_9) AT=980.025n

.meas tran vdout1_10ck1950 FIND v(dout1_10) AT=980.025n

.meas tran vdout1_11ck1950 FIND v(dout1_11) AT=980.025n

.meas tran vdout1_12ck1950 FIND v(dout1_12) AT=980.025n

.meas tran vdout1_13ck1950 FIND v(dout1_13) AT=980.025n

.meas tran vdout1_14ck1950 FIND v(dout1_14) AT=980.025n

.meas tran vdout1_15ck1950 FIND v(dout1_15) AT=980.025n

.meas tran vdout1_0ck1960 FIND v(dout1_0) AT=985.025n

.meas tran vdout1_1ck1960 FIND v(dout1_1) AT=985.025n

.meas tran vdout1_2ck1960 FIND v(dout1_2) AT=985.025n

.meas tran vdout1_3ck1960 FIND v(dout1_3) AT=985.025n

.meas tran vdout1_4ck1960 FIND v(dout1_4) AT=985.025n

.meas tran vdout1_5ck1960 FIND v(dout1_5) AT=985.025n

.meas tran vdout1_6ck1960 FIND v(dout1_6) AT=985.025n

.meas tran vdout1_7ck1960 FIND v(dout1_7) AT=985.025n

.meas tran vdout1_8ck1960 FIND v(dout1_8) AT=985.025n

.meas tran vdout1_9ck1960 FIND v(dout1_9) AT=985.025n

.meas tran vdout1_10ck1960 FIND v(dout1_10) AT=985.025n

.meas tran vdout1_11ck1960 FIND v(dout1_11) AT=985.025n

.meas tran vdout1_12ck1960 FIND v(dout1_12) AT=985.025n

.meas tran vdout1_13ck1960 FIND v(dout1_13) AT=985.025n

.meas tran vdout1_14ck1960 FIND v(dout1_14) AT=985.025n

.meas tran vdout1_15ck1960 FIND v(dout1_15) AT=985.025n

.meas tran vdout1_0ck1970 FIND v(dout1_0) AT=990.025n

.meas tran vdout1_1ck1970 FIND v(dout1_1) AT=990.025n

.meas tran vdout1_2ck1970 FIND v(dout1_2) AT=990.025n

.meas tran vdout1_3ck1970 FIND v(dout1_3) AT=990.025n

.meas tran vdout1_4ck1970 FIND v(dout1_4) AT=990.025n

.meas tran vdout1_5ck1970 FIND v(dout1_5) AT=990.025n

.meas tran vdout1_6ck1970 FIND v(dout1_6) AT=990.025n

.meas tran vdout1_7ck1970 FIND v(dout1_7) AT=990.025n

.meas tran vdout1_8ck1970 FIND v(dout1_8) AT=990.025n

.meas tran vdout1_9ck1970 FIND v(dout1_9) AT=990.025n

.meas tran vdout1_10ck1970 FIND v(dout1_10) AT=990.025n

.meas tran vdout1_11ck1970 FIND v(dout1_11) AT=990.025n

.meas tran vdout1_12ck1970 FIND v(dout1_12) AT=990.025n

.meas tran vdout1_13ck1970 FIND v(dout1_13) AT=990.025n

.meas tran vdout1_14ck1970 FIND v(dout1_14) AT=990.025n

.meas tran vdout1_15ck1970 FIND v(dout1_15) AT=990.025n

.meas tran vdout1_0ck1980 FIND v(dout1_0) AT=995.025n

.meas tran vdout1_1ck1980 FIND v(dout1_1) AT=995.025n

.meas tran vdout1_2ck1980 FIND v(dout1_2) AT=995.025n

.meas tran vdout1_3ck1980 FIND v(dout1_3) AT=995.025n

.meas tran vdout1_4ck1980 FIND v(dout1_4) AT=995.025n

.meas tran vdout1_5ck1980 FIND v(dout1_5) AT=995.025n

.meas tran vdout1_6ck1980 FIND v(dout1_6) AT=995.025n

.meas tran vdout1_7ck1980 FIND v(dout1_7) AT=995.025n

.meas tran vdout1_8ck1980 FIND v(dout1_8) AT=995.025n

.meas tran vdout1_9ck1980 FIND v(dout1_9) AT=995.025n

.meas tran vdout1_10ck1980 FIND v(dout1_10) AT=995.025n

.meas tran vdout1_11ck1980 FIND v(dout1_11) AT=995.025n

.meas tran vdout1_12ck1980 FIND v(dout1_12) AT=995.025n

.meas tran vdout1_13ck1980 FIND v(dout1_13) AT=995.025n

.meas tran vdout1_14ck1980 FIND v(dout1_14) AT=995.025n

.meas tran vdout1_15ck1980 FIND v(dout1_15) AT=995.025n

.meas tran vdout1_0ck2010 FIND v(dout1_0) AT=1010.025n

.meas tran vdout1_1ck2010 FIND v(dout1_1) AT=1010.025n

.meas tran vdout1_2ck2010 FIND v(dout1_2) AT=1010.025n

.meas tran vdout1_3ck2010 FIND v(dout1_3) AT=1010.025n

.meas tran vdout1_4ck2010 FIND v(dout1_4) AT=1010.025n

.meas tran vdout1_5ck2010 FIND v(dout1_5) AT=1010.025n

.meas tran vdout1_6ck2010 FIND v(dout1_6) AT=1010.025n

.meas tran vdout1_7ck2010 FIND v(dout1_7) AT=1010.025n

.meas tran vdout1_8ck2010 FIND v(dout1_8) AT=1010.025n

.meas tran vdout1_9ck2010 FIND v(dout1_9) AT=1010.025n

.meas tran vdout1_10ck2010 FIND v(dout1_10) AT=1010.025n

.meas tran vdout1_11ck2010 FIND v(dout1_11) AT=1010.025n

.meas tran vdout1_12ck2010 FIND v(dout1_12) AT=1010.025n

.meas tran vdout1_13ck2010 FIND v(dout1_13) AT=1010.025n

.meas tran vdout1_14ck2010 FIND v(dout1_14) AT=1010.025n

.meas tran vdout1_15ck2010 FIND v(dout1_15) AT=1010.025n

.meas tran vdout1_0ck2030 FIND v(dout1_0) AT=1020.025n

.meas tran vdout1_1ck2030 FIND v(dout1_1) AT=1020.025n

.meas tran vdout1_2ck2030 FIND v(dout1_2) AT=1020.025n

.meas tran vdout1_3ck2030 FIND v(dout1_3) AT=1020.025n

.meas tran vdout1_4ck2030 FIND v(dout1_4) AT=1020.025n

.meas tran vdout1_5ck2030 FIND v(dout1_5) AT=1020.025n

.meas tran vdout1_6ck2030 FIND v(dout1_6) AT=1020.025n

.meas tran vdout1_7ck2030 FIND v(dout1_7) AT=1020.025n

.meas tran vdout1_8ck2030 FIND v(dout1_8) AT=1020.025n

.meas tran vdout1_9ck2030 FIND v(dout1_9) AT=1020.025n

.meas tran vdout1_10ck2030 FIND v(dout1_10) AT=1020.025n

.meas tran vdout1_11ck2030 FIND v(dout1_11) AT=1020.025n

.meas tran vdout1_12ck2030 FIND v(dout1_12) AT=1020.025n

.meas tran vdout1_13ck2030 FIND v(dout1_13) AT=1020.025n

.meas tran vdout1_14ck2030 FIND v(dout1_14) AT=1020.025n

.meas tran vdout1_15ck2030 FIND v(dout1_15) AT=1020.025n
